# Altium project PROC074A.PrjPcb (part 3 of 4)

## Sheet PROC074A_CAN_Interface.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 13; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C1  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C2  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C3  VDC_V: 50V  ValueDisplayed: 4700pF  [0402L]  (hidden comment: C1005X7R1H472K050BA)
C4  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C88  ValueDisplayed: 2.2uF  [0402_065L]  (hidden comment: C1005X7S1A225K050BC)
C119  VDC_V: 50V  ValueDisplayed: 33pF  [0402L]  (hidden comment: C0402C330J5GAC)
C120  ValueDisplayed: 1µF  [0402L]  (hidden comment: C1005X7S0J105M050BC)
J1  OSTTE030161  [On-Shore_OSTTE030161]
P1  TSW-102-07-G-S  [TSW-102-07-X-S]  (value not drawn)
R1  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R2  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R3  ValueDisplayed: 0  [0402L]  (hidden comment: ERJ-2GE0R00X)
R4  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R5  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R6  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R7  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R8  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R260  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R261  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R395  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R396  ValueDisplayed: 14.0k  [0402L]  (hidden comment: CRCW040214K0FKED)
R397  ValueDisplayed: 35000  [0402L]  (hidden comment: PNM0402E3502BST1)
U1  TCAN1042HGVDQ1  [D0008A_L]
U2  TS3A5018RSVR  [RSV0016A]
U30  TPS79601DRBR  [DRB0008B]

### Blocks framed on the sheet
VPP Supply: C88 C119 C120 P1 R395-R397 U30

### Ports
CAN1_RX, CAN1_TX, CAN2_RX, CAN2_TX, MUX_IN_11 (in), RADAR_GPIO_0, RADAR_SPI_CLK1, RADAR_SPI_CS1, RADAR_SPI_MISO1, RADAR_SPI_MOSI1, SPI_CLK1, SPI_CS1, SPI_MISO1, SPI_MOSI1

### Nets
5V_IN: R3.2
BRD_3V3: C2.2 C4.1 C88.2 R4.1 R260.2 R395.1 U1.5(VIO) U2.14(V+) U30.1(IN) U30.2(IN)
GND: C1.1 C2.1 C3.1 C4.2 C88.1 C120.1 J1.2 R5.2 R261.1 R397.1 U1.2(GND) U2.6(GND) U30.6(GND) U30.9(GND)
VPP_1P7: P1.1
CAN1_RX: R8.1 U2.3(NC2) ; port CAN1_RX
CAN1_TX: R6.1 U2.16(NC1) ; port CAN1_TX
CAN2_RX: U2.9(NC3) ; port CAN2_RX
CAN2_TX: U2.12(NC4) ; port CAN2_TX
MUX_IN_11: R260.1 U2.15(IN) ; port MUX_IN_11
RADAR_GPIO_0: R1.2 ; port RADAR_GPIO_0
RADAR_SPI_CLK1: U2.7(COM3) ; port RADAR_SPI_CLK1
RADAR_SPI_CS1: U2.10(COM4) ; port RADAR_SPI_CS1
RADAR_SPI_MISO1: U2.2(COM1) ; port RADAR_SPI_MISO1
RADAR_SPI_MOSI1: U2.5(COM2) ; port RADAR_SPI_MOSI1
SPI_CLK1: U2.8(NO3) ; port SPI_CLK1
SPI_CS1: U2.11(NO4) ; port SPI_CS1
SPI_MISO1: U2.1(NO1) ; port SPI_MISO1
SPI_MOSI1: U2.4(NO2) ; port SPI_MOSI1
NetC1_2: C1.2 R3.1 U1.3(VCC)
NetC3_2: C3.2 R2.1 R7.2
NetC119_1: C119.1 C120.2 P1.2 R396.2 U30.3(OUT) U30.4(OUT)
NetC119_2: C119.2 R396.1 R397.2 U30.5(FB)
NetJ1_1: J1.1 R2.2 U1.7(CANH)
NetJ1_3: J1.3 R7.1 U1.6(CANL)
NetR1_1: R1.1 R4.2 R5.1 U1.8(STB)
NetR6_2: R6.2 U1.1(TXD)
NetR8_2: R8.2 U1.4(RXD)
NetR261_2: R261.2 U2.13(~{EN})
NetR395_2: R395.2 U30.8(EN)

Not connected (* = marked no-connect by the designer): U30 7(NC)*

### Notes on the sheet
- CAN_FD TRANSCEIVER
- (near J1) CANH
- (near J1) GND
- (near J1) CANL
- CAN/SPI SELECTION
- MUX IN CONFIG
- S1.1 OFF   : SPI-1
- S1.1 ON     : CAN1 & CAN2

### Library data of the parts
C1 C2 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Value2: 10V; CompType: Capacitor; Cap_F: 100nF; AEC Category: Q200
C3 = CMP-0078221-1: CAP, CERM, 4700 pF, 50 V,+/- 10%, X7R, 0402; Manufacturer: TDK; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 4700pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Cap_F: 4.7nF; AEC Category: Q200
C4 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 10V; CompType: Capacitor; Cap_F: 100nF; AEC Category: Q200
C88 = CMP-0006302-2: CAP, CERM, 2.2 uF, 10 V, +/- 10%, X7S, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 5.925m; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.005925 ohm; U/M: EA; Value: 2.2uF; TaMax_C: 125°C; SizeZ_mm: 0.65; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402_065; Value2: 10V; CompType: Capacitor; Cap_F: 2.2µF; IRMS_A: 2.05591A; AEC Category: Q200
C119 = CMP-0006242-2: CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 33pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; AEC Category: Q200
C120 = CMP-0078222-1: CAP, CERM, 1 µF, 6.3 V,+/- 20%, X7S, 0402; Manufacturer: TDK; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Value2: 6.3V; CompType: Capacitor; AEC Category: Q200
J1 = CMP-0075352-1: Terminal Block, 3.5mm, 3x1, Tin, R/A, TH; Manufacturer: On-Shore Technology; CNHeader: False; Current_A: 10A; Green_Lifecycle: Not Set; Gender: Female; Cert_CSA: Y; Green_REACh: Incomplete; Voltage_V: 125V; Row_Count: 1; Pitch_mm: 3.5; CT: True
P1 = CMP-0075405-1: Header, 100mil, 2x1, Gold, TH; Manufacturer: Samtec; Pitch_mm: 2.54; Cert_VDE: N; Gender: Male; Cert_CSA: Y; Voltage_V: 550V; Green_REACh: Passed; Current_A: 6.3A; CT: False; Green_Lifecycle: Active; Row_Count: 1; CNHeader: True
R1 R6 R8 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 600 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; SizeAreaWB_mm2: 3; INSTALLATION: DNP
R2 R7 = CMP-0026491-1: RES, 61.9, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 61R9; U/M: EA; Value: 61.9; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
R3 = CMP-0026992-2: RES, 0, 5%, 0.063 W, 0402; Manufacturer: Panasonic; Power_W: 63mW; TempCo: 600 ppm/C; Value_Code: 0000; U/M: EA; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
R4 = CMP-0025958-2: RES, 10.0 k, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; U/M: EA; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; VDC_V: 50V; AEC Category: Q200; INSTALLATION: DNP
R5 R260 R395 = CMP-0025958-2: RES, 10.0 k, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; U/M: EA; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
R261 = CMP-0026938-5: RES, 4.7 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 4k70; Value: 4.7k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R396 = CMP-0026015-2: RES, 14.0 k, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 14k0; U/M: EA; Value: 14.0k; EIA_Code: E96; Res_ohm: 14k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
R397 = CMP-0078213-1: RES, 35000, 0.1%, 0.05 W, 0402; Manufacturer: Vishay-Dale; Value_Code: 35k0; SizeArea_mm2: 0.5; AEC Qualified: N; AEC Category: Q200; Res_ohm: 35k; Value: 35.0k; SizeZ_mm: 0.6; TempCo: 25 ppm/C; Power_W: 50mW; VDC_V: 75V; Value2: 0.05W; U/M: EA; SizeX_mm: 1
U1 = CMP-0075992-1: Automotive Fault Protected CAN Transceiver With Flexible Data-Rate, D0008A (SOIC-8); Manufacturer: Texas Instruments; Alternate PartNumber: TCAN1042HGVDRQ1; SizeAreaWB_mm2: 56.58; SizeArea_mm2: 30.38; SizeZ_mm: 1.75; SizeY_mm: 6.2; U/M: EA; CompType: IC; SizeX_mm: 4.9
U2 = CMP-0067415-1: 10-Ohm Quad SPDT Analog Switch, RSV0016A (UQFN-16); Alternate Manufacturer: Texas Instruments; SizeAreaWB_mm2: 10.08; U/M: EA; SizeZ_mm: 0.55; SizeX_mm: 1.8; SizeY_mm: 2.6; SizeArea_mm2: 4.68; CompType: IC
U30 = CMP-0036402-2: Single Output High PSRR LDO, 1 A, Adjustable 1.2 to 5.5 V Output, 2.7 to 5.5 V Input, 8-pin SON (DRB), -40 to 125 degC, Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Vin(Min)(V): 2.7; Vout Adj(Max)(V): 5.5; Vout Adj(Min)(V): 1.2; Accuracy(%): 2; SubFamily: Single Channel LDO; Iq(Typ)(mA): 0.26; Vdo(Typ)(mV): 250; Iout(Max)(A): 1

## Sheet PROC074A_SOP_Selection.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 14; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
P4  TSW-102-07-G-S  [TSW-102-07-X-S]
P5  TSW-102-07-G-S  [TSW-102-07-X-S]
P6  TSW-102-07-G-S  [TSW-102-07-X-S]
R131  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R132  ValueDisplayed: 750  [0402L]  (hidden comment: CRCW0402750RFKED)
R133  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R134  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R135  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)
R136  ValueDisplayed: 750  [0402L]  (hidden comment: CRCW0402750RFKED)
R137  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R138  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R139  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)
R140  ValueDisplayed: 750  [0402L]  (hidden comment: CRCW0402750RFKED)
R141  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R142  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R143  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)

### Ports
60PIN_JTAG_TDO_SOP0, MCU_SOP0, MCU_SOP1, MCU_SOP2, PMIC_CLK, RADAR_PMIC_CLKOUT_SOP2, RADAR_SYNC_OUT_SOP1

### Nets
BRD_3V3: P4.2 P5.2 P6.2
GND: R135.1 R139.1 R143.1
60PIN_JTAG_TDO_SOP0: R141.1 ; port 60PIN_JTAG_TDO_SOP0
MCU_SOP0: R140.2 ; port MCU_SOP0
MCU_SOP1: R136.2 ; port MCU_SOP1
MCU_SOP2: R132.2 ; port MCU_SOP2
PMIC_CLK: R131.2 ; port PMIC_CLK
RADAR_PMIC_CLKOUT_SOP2: R131.1 R133.1 ; port RADAR_PMIC_CLKOUT_SOP2
RADAR_SYNC_OUT_SOP1: R137.1 ; port RADAR_SYNC_OUT_SOP1
NetP4_1: P4.1 R134.2
NetP5_1: P5.1 R138.2
NetP6_1: P6.1 R142.2
NetR132_1: R132.1 R133.2 R134.1 R135.2
NetR136_1: R136.1 R137.2 R138.1 R139.2
NetR140_1: R140.1 R141.2 R142.1 R143.2

### Notes on the sheet
- SOP HEADERS
- SOP_MODE2
- SOP_MODE4
- SOP_MODE5
- "011"
- "001"
- "101"
- DEV/FLED
- FUNC - > DEFAULT VALUE FOR OUTPUTS
- DEV MANAGEMENT -> FOR FLASHING

### Library data of the parts
P4-P6 = CMP-0075405-1: as P1 on sheet PROC074A_CAN_Interface
R131 = CMP-0026992-3: as R1 on sheet PROC074A_CAN_Interface
R132 R136 R140 = CMP-0026542-1: RES, 750, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 750R; U/M: EA; Value: 750; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R133 R137 R141 = CMP-0025958-2: as R5 on sheet PROC074A_CAN_Interface
R134 R138 = CMP-0026557-1: RES, 7.87 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 7k87; U/M: EA; Value: 7.87k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R135 R139 R143 = CMP-0026574-1: RES, 82.5 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 82k5; U/M: EA; Value: 82.5k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R142 = CMP-0026557-1: RES, 7.87 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 7k87; U/M: EA; Value: 7.87k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200

## Sheet PROC074A_Temp_Sensor.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 15; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C49  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C50  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
R171  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R172  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R173  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R174  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R175  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R176  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R177  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R178  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R179  ValueDisplayed: 0  [0402L]  (hidden comment: ERJ-2GE0R00X)
R180  ValueDisplayed: 0  [0402L]  (hidden comment: ERJ-2GE0R00X)
U18  TMP112AIDRLR  [DRL0006A]
U19  TMP112AIDRLR  [DRL0006A]

### Ports
RADAR_SCL, RADAR_SDA

### Nets
BRD_3V3: R176.1 R177.1 R178.2 R179.2 R180.2
GND: C49.1 C50.2 R172.1 U18.2(GND) U19.2(GND)
RADAR_SCL: R171.1 R173.1 ; port RADAR_SCL
RADAR_SDA: R174.2 R175.2 ; port RADAR_SDA
NetC49_2: C49.2 R180.1 U19.5(V+)
NetC50_1: C50.1 R179.1 U18.5(V+)
NetR171_2: R171.2 U18.1(SCL)
NetR172_2: R172.2 U19.4(ADD0)
NetR173_2: R173.2 U19.1(SCL)
NetR174_1: R174.1 U18.6(SDA)
NetR175_1: R175.1 U19.6(SDA)
NetR176_2: R176.2 U18.3(ALERT)
NetR177_2: R177.2 U19.3(ALERT)
NetR178_1: R178.1 U18.4(ADD0)

### Notes on the sheet
- ONBOARD TEMP SENSORS
- I2C ADDRESS: 100 1001
- TEMP SENSOR CLOSE TO PMIC
- I2C Address : 100 1000
- TEMP SENSOR AWAY FROM PMIC

### Library data of the parts
C49 C50 = CMP-0078241-1: as C1 on sheet PROC074A_CAN_Interface
R171-R175 R178 = CMP-0027008-3: RES, 0, 5%, 0.05 W, 0201; Manufacturer: Vishay-Dale; Power_W: 50mW; TempCo: ppm/C; Value_Code: 0000; U/M: EA; Value: 0; EIA_Code: E24; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; Value2: 0.05W; SizeArea_mm2: 0.18; AEC Qualified: N; AEC Category: Q200
R176 R177 = CMP-0025958-2: as R5 on sheet PROC074A_CAN_Interface
R179 R180 = CMP-0026992-2: as R3 on sheet PROC074A_CAN_Interface
U18 U19 = CMP-0067397-2: 1.4V-Capable +/-0.5degC Temperature Sensor with Alert Function and I2C/SMBus interface in SOT-563, DRL0006A (SOT-OTHER-6); Alternate PartNumber: TMP112AIDRLT; Alternate Manufacturer: Texas Instruments; Green_Lifecycle: Active; SizeAreaWB_mm2: 6.76; Green_REACh: Passed; U/M: EA; SizeZ_mm: 0.6; SizeX_mm: 1.6; SizeArea_mm2: 2.56; CompType: IC

## Sheet PROC074A_FTDI_Interface.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 16; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C51  ValueDisplayed: 4.7uF  [0603]  (hidden comment: C1608X7S1A475K080AC)
C52  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C53  ValueDisplayed: 4.7uF  [0603]  (hidden comment: C1608X7S1A475K080AC)
C54  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C56  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C57  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C58  ValueDisplayed: 4.7uF  [0603]  (hidden comment: C1608X7S1A475K080AC)
C59  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C60  VDC_V: 50V  ValueDisplayed: 8pF  [0402]  (hidden comment: GRM1555C1H8R0DA01D)
C61  VDC_V: 50V  ValueDisplayed: 8pF  [0402]  (hidden comment: GRM1555C1H8R0DA01D)
D4  TLMY1000-GS08  value Yellow  [TLMx1000_Yellow]
L5  BLM15HG601SN1D  [0402]
L6  BLM15HG601SN1D  [0402]
R43  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R182  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R183  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R184  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R188  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R189  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R190  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R191  ValueDisplayed: 510  [0402]  (hidden comment: ERJ-2GEJ511X)
R192  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R194  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R195  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R196  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R197  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R198  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R199  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R200  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R201  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R202  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R204  ValueDisplayed: 1.0k  [0402]  (hidden comment: ERJ-2GEJ102X)
R205  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R206  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R207  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R208  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R210  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R211  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R212  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R213  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R214  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
R215  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R216  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R217  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R218  ValueDisplayed: 33.2  [0402]  (hidden comment: CRCW040233R2FKED)
U15  FT4232HL  [LQFP64_N]
Y2  NX3225SA-12.000M-STD-CRS-2  [NDK_NX3225SA]  (value not drawn)

### Ports
EECLK, EECS, EEDATA, FTDI_CLK1, FTDI_CS1, FTDI_DSS_LOGGER, FTDI_GPIO_0, FTDI_GPIO_1, FTDI_GPIO_2, FTDI_HOST_INTR1, FTDI_I2C_SCL, FTDI_I2C_SDA, FTDI_MISO1, FTDI_MOSI1, FTDI_NERR_OUT, FTDI_NERRIN, FTDI_NRST, FTDI_PMIC_EN, FTDI_PMIC_OUT_SOR0, FTDI_RS232RX, FTDI_RS232TX, FTDI_SYNC_OUT_SOR1, FTDI_TDO_SOR2, FTDI_UART3_TX, FTDI_UART4_TX, FTDI_WARMRST, USBDM, USBDP

### Nets
FTDI_3V3: L5.1 L6.1 R189.2 R190.2 R204.1 U15.20(VCCIO) U15.31(VCCIO) U15.42(VCCIO) U15.50(VREGIN) U15.56(VCCIO)
FTDI_VCORE: C56.1 C57.1 C58.1 C59.1 U15.12(VCORE) U15.37(VCORE) U15.49(VREGOUT) U15.64(VCORE)
GND: C51.2 C52.1 C53.2 C54.1 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 D4.2(K) R201.1 U15.1(GND) U15.5(GND) U15.10(AGND) U15.11(GND) U15.13(TEST) U15.15(GND) U15.25(GND) U15.35(GND) U15.47(GND) U15.51(GND) Y2.2(GND) Y2.4(GND)
EECLK: U15.62(EECLK) ; port EECLK
EECS: U15.63(EECS) ; port EECS
EEDATA: U15.61(EEDATA) ; port EEDATA
FTDI_CLK1: R182.2 ; port FTDI_CLK1
FTDI_CS1: R188.2 ; port FTDI_CS1
FTDI_DSS_LOGGER: R192.2 R210.2 ; port FTDI_DSS_LOGGER
FTDI_GPIO_0: R215.2 ; port FTDI_GPIO_0
FTDI_GPIO_1: R216.2 ; port FTDI_GPIO_1
FTDI_GPIO_2: R217.2 ; port FTDI_GPIO_2
FTDI_HOST_INTR1: R198.2 R199.2 ; port FTDI_HOST_INTR1
FTDI_I2C_SCL: R189.1 R194.2 ; port FTDI_I2C_SCL
FTDI_I2C_SDA: R190.1 R195.2 R196.2 ; port FTDI_I2C_SDA
FTDI_MISO1: R184.2 ; port FTDI_MISO1
FTDI_MOSI1: R183.2 ; port FTDI_MOSI1
FTDI_NERR_OUT: R207.2 ; port FTDI_NERR_OUT
FTDI_NERRIN: R206.2 ; port FTDI_NERRIN
FTDI_NRST: R208.2 ; port FTDI_NRST
FTDI_PMIC_EN: R197.2 ; port FTDI_PMIC_EN
FTDI_PMIC_OUT_SOR0: R212.2 ; port FTDI_PMIC_OUT_SOR0
FTDI_RS232RX: R202.2 ; port FTDI_RS232RX
FTDI_RS232TX: R205.2 ; port FTDI_RS232TX
FTDI_SUSPEND_N: R191.2 R218.2
FTDI_SYNC_OUT_SOR1: R213.2 ; port FTDI_SYNC_OUT_SOR1
FTDI_TDO_SOR2: R214.2 ; port FTDI_TDO_SOR2
FTDI_UART3_TX: R43.2 ; port FTDI_UART3_TX
FTDI_UART4_TX: R200.2 R211.2 ; port FTDI_UART4_TX
FTDI_WARMRST: U15.46(CDBUS7) ; port FTDI_WARMRST
USBDM: U15.7(DM) ; port USBDM
USBDP: U15.8(DP) ; port USBDP
NetC51_1: C51.1 C52.2 L5.2 U15.4(VPHY)
NetC53_1: C53.1 C54.2 L6.2 U15.9(VPLL)
NetC60_1: C60.1 U15.3(OSCO) Y2.3
NetC61_1: C61.1 U15.2(OSCI) Y2.1
NetD4_1: D4.1(A) R191.1
NetR43_1: R43.1 R200.1 R205.1 U15.39(CDBUS1)
NetR182_1: R182.1 U15.16(ADBUS0)
NetR183_1: R183.1 U15.17(ADBUS1)
NetR184_1: R184.1 U15.18(ADBUS2)
NetR188_1: R188.1 U15.19(ADBUS3)
NetR192_1: R192.1 R195.1 U15.27(BDBUS1)
NetR194_1: R194.1 U15.26(BDBUS0)
NetR196_1: R196.1 U15.28(BDBUS2)
NetR197_1: R197.1 U15.30(BDBUS4)
NetR198_1: R198.1 U15.32(BDBUS5)
NetR199_1: R199.1 U15.34(BDBUS7)
NetR201_2: R201.2 U15.6(REF)
NetR202_1: R202.1 U15.38(CDBUS0)
NetR204_2: R204.2 U15.14(RESET#)
NetR206_1: R206.1 U15.43(CDBUS4)
NetR207_1: R207.1 U15.44(CDBUS5)
NetR208_1: R208.1 U15.45(CDBUS6)
NetR210_1: R210.1 R211.1 U15.52(DDBUS1)
NetR212_1: R212.1 U15.53(DDBUS2)
NetR213_1: R213.1 U15.54(DDBUS3)
NetR214_1: R214.1 U15.55(DDBUS4)
NetR215_1: R215.1 U15.57(DDBUS5)
NetR216_1: R216.1 U15.58(DDBUS6)
NetR217_1: R217.1 U15.59(DDBUS7)
NetR218_1: R218.1 U15.36(SUSPEND#)

Not connected (* = marked no-connect by the designer): U15 21(ADBUS4)* 22(ADBUS5)* 23(ADBUS6)* 24(ADBUS7)* 29(BDBUS3)* 33(BDBUS6)* 40(CDBUS2)* 41(CDBUS3)* 48(DDBUS0)* 60(PWREN#)*

### Notes on the sheet
- FTDI INTERFACE

### Library data of the parts
C51 C53 C58 = CMP-0007058-4: CAP, CERM, 4.7 uF, 10 V, +/- 10%, X7S, 0603; Manufacturer: TDK; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 4.68; Value1: Unknown; U/M: EA; Value: 4.7uF; TaMax_C: 125°C; SizeZ_mm: 1; SizeX_mm: 1.6; SizeY_mm: 0.8; Value2: 10V; SizeArea_mm2: 1.28; CompType: Capacitor; Cap_F: 4.7µF; AEC Category: Q200
C52 C54 C56 C57 C59 = CMP-0078241-1: as C4 on sheet PROC074A_CAN_Interface
C60 C61 = CMP-0006494-2: CAP, CERM, 8 pF, 50 V, +/- 6%, C0G/NP0, 0402; Manufacturer: MuRata; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 8pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Category: Q200
D4 = CMP-0078196-1: LED, Yellow, SMD; Manufacturer: Vishay-Semiconductor; Tjmax_C: 120°C; SizeAreaWB_mm2: 4.68; Vr_V: 6V; Power_TotalModule: 40mW; Angle: 160; SizeArea_mm2: 1.28; Ir_A: 10µA; SizeZ_mm: 0.65; Io_A: 2mA; Vf_V: 1.8V; SizeY_mm: 0.8; U/M: EA; Value1: .04W; SizeX_mm: 1.6; Type: AlInGaP
L5 L6 = CMP-0081523-1: Ferrite Bead, 600 ohm @ 100 MHz, 0.3 A, 0402; Manufacturer: MuRata; SizeAreaWB_mm2: 3; SizeArea_mm2: 0.5; Value: 600 ohm; SizeZ_mm: 0.6; Imax_A: 3dA; ZTyp@100MHz_Ohm: 600; Value2: 0.3A; Value1: 0.7 ohm; DCR_ohm: 7d; SizeX_mm: 1; Ztyp@1GHz_Ohm: 1k
R43 R192 R202 R205 R211 R215-R217 = CMP-0026992-3: as R1 on sheet PROC074A_CAN_Interface
R182 R183 R188 R197 R206 R208 R212-R214 R218 = CMP-0026299-2: RES, 33.2, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 33R2; Value: 33.2; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R184 R194-R196 R198-R200 R207 R210 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 600 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; SizeAreaWB_mm2: 3
R189 R190 = CMP-0025958-3: RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0; INSTALLATION: DNP
R191 = CMP-0078212-1: RES, 510, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Value_Code: 510R; SizeArea_mm2: 0.5; AEC Qualified: Y; AEC Category: Q200; Value: 510; SizeZ_mm: 0.6; EIA_Code: E24; TempCo: 200 ppm/C; AEC Grade: 0; Power_W: 100mW; VDC_V: 50V; Value2: 0.1W; U/M: EA; SizeX_mm: 1
R201 = CMP-0025958-3: RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R204 = CMP-0078193-1: RES, 1.0 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Value_Code: 1k00; SizeArea_mm2: 0.5; AEC Qualified: Y; AEC Category: Q200; Res_ohm: 1k; Value: 1.0k; SizeZ_mm: 0.6; Green_REACh: Passed; EIA_Code: E24; TempCo: 200 ppm/C; AEC Grade: 0; Power_W: 100mW; VDC_V: 50V; Value2: 0.1W; Green_Lifecycle: Active; U/M: EA; SizeX_mm: 1
U15 = CMP-0004747-1: Quad High Speed USB to Multipurpose UART/MPSSE IC; Manufacturer: FTDI
Y2 = CMP-0081529-1: Crystal, 12 MHz, 15 ppm, 8 pF, AEC-Q200 Grade 1, SMD; Manufacturer: NDK; TaMin_C: -40°C; Frequency Tolerance: 15 ppm; Frequency Stability: 50 ppm; Load Capacitance: 8 pF; Frequency_Fixed: 12MHz; TaMax_C: 125°C; AEC Qualified: Y; AEC Grade: 1; AEC Category: Q200

## Sheet PROC074A_FTDI_Interface_PWR.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 17; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C55  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C62  ValueDisplayed: 2.2uF  [0402_065]  (hidden comment: C1005X7S1A225K050BC)
C63  VDC_V: 10V  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C64  VDC_V: 50V  ValueDisplayed: 15pF  [0402]  (hidden comment: 04025A150FAT2A)
C65  ValueDisplayed: 2.2uF  [0402_065]  (hidden comment: C1005X7S1A225K050BC)
C66  ValueDisplayed: 1uF  [0603]  (hidden comment: GCM188R71C105KA64D)
C67  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C68  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C69  ValueDisplayed: 1uF  [0603]  (hidden comment: GCM188R71C105KA64D)
C70  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
J12  105017-0001  [CONN_105017-0001]
J13  22284033  [Molex_0022284033]
R181  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R185  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R186  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R187  ValueDisplayed: 10.0k  [0402]  (hidden comment: CRCW040210K0FKED)
R193  ValueDisplayed: 2.2k  [0402]  (hidden comment: CRCW04022K20JNED)
R219  ValueDisplayed: 0  [0805_HV]  (hidden comment: CRCW08050000Z0EA)
R220  ValueDisplayed: 0  [0805]  (hidden comment: CRCW08050000Z0EA)
R221  ValueDisplayed: 0  [0805]  (hidden comment: CRCW08050000Z0EA)
R222  ValueDisplayed: 49.9k  [0402]  (hidden comment: CRCW040249K9FKED)
R223  ValueDisplayed: 30.0k  [0402]  (hidden comment: CRCW040230K0FKED)
R225  ValueDisplayed: 29.4k  [0402]  (hidden comment: CRCW040229K4FKED)
R226  ValueDisplayed: 100k  [0402]  (hidden comment: CRCW0402100KFKED)
R227  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R228  ValueDisplayed: 100k  [0402]  (hidden comment: CRCW0402100KFKED)
R290  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
U14  93LC46B-I/ST  [TSSOP-8]
U16  TPD4E004DRYR  [DRY0006A]
U17  TPS79601DRBR  [DRB0008B]

### Ports
EECLK, EECS, EEDATA, PGOOD, USBDM, USBDP, USBID

### Nets
BP_LP_3V3: J13.3
BRD_3V3: J13.2
FTDI_3V3: C66.1 C67.1 C68.1 C69.1 C70.1 R181.2 R185.2 R186.2 R187.2 R221.2
FTDI_VBUS: C62.1 R219.2 R220.2 R228.2 U17.1(IN) U17.2(IN)
GND: C55.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 J12.5 R223.1 R225.2 R226.1 R227.1 U14.5(VSS) U16.3(GND) U17.6(GND) U17.9(GND)
VLDO_3V3: C64.1 C65.1 J13.1 R221.1 R222.2 U17.3(OUT) U17.4(OUT)
3V3_MON_FTDI: R226.2 R228.1 R290.1 U17.8(EN)
EECLK: R185.1 U14.2(CLK) ; port EECLK
EECS: R186.1 U14.1(CS) ; port EECS
EEDATA: R187.1 R193.1 U14.3(DI) ; port EEDATA
PGOOD: R290.2 ; port PGOOD
USBDM: J12.2 U16.4(IO3) ; port USBDM
USBDP: J12.3 U16.1(IO1) ; port USBDP
USBID: J12.4 U16.2(IO2) ; port USBID
NetC55_1: C55.1 R181.1 U14.8(VCC)
NetC63_1: C63.1 R220.1 U16.6(VCC)
NetJ12_1: J12.1 R219.1
NetJ12_6: J12.6 J12.7 J12.8 J12.9 J12.10 J12.11 R227.2
NetR193_2: R193.2 U14.4(DO)
NetR222_1: R222.1 R225.1 U17.5(FB)
NetR223_2: R223.2 U16.5(IO4)

Not connected (* = marked no-connect by the designer): U14 6(NC)* 7(NC)*; U17 7(NC)*

### Notes on the sheet
- FTDI POWER SECTION
- 3.3V LDO FOR FTDI
- FTDI EEPROM
- THIS 3.3V LDO WILL TURN ON
- EITHER FOR IWR6XXX MODULE BOARD
- OR CARRIER BOARD IS POWERED UP
- 3.3V SUPPLY SELECTION JUMPER
- (near J13) POS 1-2: FROM FTDI LDO
- POS 2-3: FROM 40PIN LP/BP CONNECTOR

### Library data of the parts
C55 C67 C68 C70 = CMP-0078241-1: as C4 on sheet PROC074A_CAN_Interface
C62 C65 = CMP-0006302-2: CAP, CERM, 2.2 uF, 10 V, +/- 10%, X7S, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 5.925m; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.005925 ohm; U/M: EA; Value: 2.2uF; TaMax_C: 125°C; SizeZ_mm: 0.65; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 10V; CompType: Capacitor; Cap_F: 2.2µF; IRMS_A: 2.05591A; AEC Category: Q200
C63 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_F: 100nF; AEC Category: Q200
C64 = CMP-0078217-1: CAP, CERM, 15 pF, 50 V,+/- 1%, C0G/NP0, 0402; Manufacturer: AVX; TaMin_C: -55°C; Polarized: N; Green_Lifecycle: Not Set; SizeAreaWB_mm2: 3; Green_REACh: Incomplete; U/M: EA; Value: 15pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Category: Q200
C66 C69 = CMP-0007136-5: CAP, CERM, 1 uF, 16 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0603; Manufacturer: MuRata; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 4.68; Value1: Unknown; U/M: EA; Value: 1uF; TaMax_C: 125°C; SizeZ_mm: 1; SizeX_mm: 1.6; SizeY_mm: 0.8; Value2: 16V; SizeArea_mm2: 1.28; CompType: Capacitor; AEC Qualified: Y; Cap_F: 1µF; AEC Category: Q200
J12 = CMP-0055293-1: Connector, Receptacle, Micro-USB Type B, R/A, Bottom Mount SMT; Manufacturer: Molex; CNHeader: FALSE; Green_Lifecycle: Active; Gender: Female; Green_REACh: Passed; CompType: USB; CT: TRUE
J13 = CMP-0055332-1: Header, 2.54mm, 3x1, Tin, TH; Manufacturer: Molex; CNHeader: TRUE; Current_A: 4A; Shrouded: N; Gender: Male; Voltage_V: 250V; Row_Count: 1; Pitch_mm: 2.54; CT: FALSE; Cert_UL: Y
R181 R227 R290 = CMP-0026992-3: as R184 on sheet PROC074A_FTDI_Interface
R185-R187 = CMP-0025958-3: as R201 on sheet PROC074A_FTDI_Interface
R193 = CMP-0026890-5: RES, 2.2 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 2k20; Value: 2.2k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R219-R221 = CMP-0020442-3: RES, 0, 5%, 0.125 W, AEC-Q200 Grade 0, 0805; Manufacturer: Vishay-Dale; Power_W: 125mW; TempCo: 200 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 2; SizeY_mm: 1.25; SizeZ_mm: 1.45; Value2: 0.125W; SizeArea_mm2: 2.5; AEC Qualified: Y; VDC_V: 150V; AEC Category: Q200
R222 = CMP-0026403-2: RES, 49.9 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 49k9; Value: 49.9k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R223 = CMP-0078244-2: RES, 30.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; Green_Lifecycle: Active; TempCo: 100 ppm/C; Value_Code: 30k0; Green_REACh: Passed; Value: 30.0k; Res_ohm: 30k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R225 = CMP-0026225-2: RES, 29.4 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 29k4; Value: 29.4k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R226 = CMP-0025950-3: RES, 100 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value: 100k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R228 = CMP-0025950-3: RES, 100 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value: 100k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0; INSTALLATION: DNP
U14 = CMP-0081524-1: 1K Microwire Compatible Serial EEPROM, TSSOP-8; Manufacturer: Microchip; SizeArea_mm2: 19.2; SizeAreaWB_mm2: 42; SizeY_mm: 3; SizeZ_mm: 1.2; SizeX_mm: 6.4
U16 = CMP-0043115-2: ESD-Protection Array for High-Speed Data Interfaces, 4 Channels, -40 to +85 degC, 6-pin SON (DRY), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; IO Leakage Current(nA): 1; USB High Speed: TRUE; IO Capacitance(Typ)(pF): 1.6; SubFamily: ESD Solution; IEC 61000-4-2 Contact(+/- kV): 8; Breakdown Voltage(Min)(V): 6; IEC 61000-4-2 Air-Gap(+/- kV): 12; AEC Category: Q200; AEC Qualified: N; CompType: IC; SizeAreaWB_mm2: 4.9; SizeArea_mm2: 1.45; SizeX_mm: 1.0; SizeZ_mm: 0.6
U17 = CMP-0036402-3: Single Output High PSRR LDO, 1 A, Adjustable 1.2 to 5.5 V Output, 2.7 to 5.5 V Input, 8-pin SON (DRB), -40 to 125 degC, Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Vin(Min)(V): 2.7; Vout Adj(Max)(V): 5.5; Vout Adj(Min)(V): 1.2; Accuracy(%): 2; SubFamily: Single Channel LDO; Iq(Typ)(mA): 0.26; Vdo(Typ)(mV): 250; Iout(Max)(A): 1; AEC Category: Q200; AEC Qualified: N; CompType: IC; SizeAreaWB_mm2: 16.0; SizeArea_mm2: 9.0; SizeX_mm: 3.0; SizeZ_mm: 1.0

## Sheet PROC074A_CAN_Interface_LEDs.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 18; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C5  VDC_V: 50V  ValueDisplayed: 4700pF  [0402]  (hidden comment: C1005X7R1H472K050BA)
C71  VDC_V: 50V  ValueDisplayed: 0.1uF  [0402]  (hidden comment: CGA2B3X7R1H104K050BB)
C74  VDC_V: 50V  ValueDisplayed: 0.1uF  [0402]  (hidden comment: CGA2B3X7R1H104K050BB)
C75  ValueDisplayed: 2.2uF  [0603]  (hidden comment: C0603C225K8PACTU)
C76  ValueDisplayed: 2.2uF  [0603]  (hidden comment: C0603C225K8PACTU)
C77  ValueDisplayed: 0.1uF  [0402]  (hidden comment: CGA2B3X7R1H104K050BB)
D5  TLMY1000-GS08  value Yellow  [TLMx1000_Yellow]
D6  TLMY1000-GS08  value Yellow  [TLMx1000_Yellow]
D7  TLMY1000-GS08  value Yellow  [TLMx1000_Yellow]
D8  TLMS1000-GS08  value Red  [TLMx1000_Red]
D9  TLMS1000-GS08  value Red  [TLMx1000_Red]
D10  TLMS1000-GS08  value Red  [TLMx1000_Red]
J2  OSTTE030161  [On-Shore_OSTTE030161]
L7  ValueDisplayed: 1uH  [0805_HV]  (hidden comment: LQM21PN1R0MC0D)
R10  ValueDisplayed: 510  [0402]  (hidden comment: ERJ-2GEJ511X)
R11  ValueDisplayed: 61.9  [0402]  (hidden comment: CRCW040261R9FKED)
R12  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R15  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R31  ValueDisplayed: 61.9  [0402]  (hidden comment: CRCW040261R9FKED)
R32  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R33  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R251  ValueDisplayed: 510  [0402]  (hidden comment: ERJ-2GEJ511X)
R252  ValueDisplayed: 510  [0402]  (hidden comment: ERJ-2GEJ511X)
R253  ValueDisplayed: 510  [0402]  (hidden comment: ERJ-2GEJ511X)
R254  ValueDisplayed: 1.6k  [0402]  (hidden comment: CRCW04021K60JNED)
R255  ValueDisplayed: 750  [0402]  (hidden comment: CRCW0402750RFKED)
R256  ValueDisplayed: 0  [1206]  (hidden comment: CRCW12060000Z0EA)
U3  SN65HVDA540QDR  [D0008A_N]
U12  TPS61240DRVR  [DRV0006A]

### Ports
CAN2_RX, CAN2_TX, FTDI_NRST, FTDI_PMIC_OUT_SOR0, FTDI_SYNC_OUT_SOR1, FTDI_TDO_SOR2

### Nets
5V_IN: R33.1
BOOST_3V3_IN: C75.1 L7.2 R256.2 U12.4(EN) U12.6(VIN)
BRD_3V3: C71.1 R15.2 R255.2 R256.1
FTDI_VBUS: R254.2
GND: C5.1 C71.2 C74.2 C75.2 C76.2 C77.2 D5.2(K) D6.2(K) D7.2(K) D8.2(K) D9.2(K) D10.2(K) J2.2 R12.1 U3.2(GND) U12.1(GND) U12.7(PAD)
VBOOST_5V: C76.1 C77.1 R32.1 U12.2(VOUT) U12.3(FB)
CAN2_RX: U3.4(RXD) ; port CAN2_RX
CAN2_TX: U3.1(TXD) ; port CAN2_TX
FTDI_NRST: R253.1 ; port FTDI_NRST
FTDI_PMIC_OUT_SOR0: R10.1 ; port FTDI_PMIC_OUT_SOR0
FTDI_SYNC_OUT_SOR1: R251.1 ; port FTDI_SYNC_OUT_SOR1
FTDI_TDO_SOR2: R252.1 ; port FTDI_TDO_SOR2
NetC5_2: C5.2 R11.1 R31.2
NetC74_1: C74.1 R32.2 R33.2 U3.3(VCC)
NetD5_1: D5.1(A) R10.2
NetD6_1: D6.1(A) R251.2
NetD7_1: D7.1(A) R252.2
NetD8_1: D8.1(A) R253.2
NetD9_1: D9.1(A) R254.1
NetD10_1: D10.1(A) R255.1
NetJ2_1: J2.1 R11.2 U3.7(CANH)
NetJ2_3: J2.3 R31.1 U3.6(CANL)
NetL7_1: L7.1 U12.5(L)
NetR12_2: R12.2 U3.8(STB)
NetR15_1: R15.1 U3.5(VIO)

### Notes on the sheet
- RESET & SOP STATUS INDICATION
- CAN TRANSCEIVER
- (near J2) CANH
- (near J2) GND
- (near J2) CANL
- 3.3V TO 5V BOOST CONVERTER
- 5V & 3.3V SUPPLY INDICATION

### Library data of the parts
C5 = CMP-0078221-1: CAP, CERM, 4700 pF, 50 V,+/- 10%, X7R, 0402; Manufacturer: TDK; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 4700pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_F: 4.7nF; AEC Category: Q200
C71 C74 = CMP-0006325-2: CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 0.039064; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.039064 ohm; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; AEC Qualified: Y; Cap_F: 100nF; IRMS_A: 8.14669dA; AEC Category: Q200
C75 C76 = CMP-0006906-5: CAP, CERM, 2.2 uF, 10 V, +/- 10%, X5R, 0603; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 4.68; Value1: Unknown; U/M: EA; Value: 2.2uF; TaMax_C: 85°C; SizeZ_mm: 1; SizeX_mm: 1.6; SizeY_mm: 0.8; Value2: 10V; SizeArea_mm2: 1.28; CompType: Capacitor; Cap_F: 2.2µF; AEC Category: Q200
C77 = CMP-0006325-2: CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 0.039064; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.039064 ohm; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 50V; CompType: Capacitor; AEC Qualified: Y; Cap_F: 100nF; IRMS_A: 8.14669dA; AEC Category: Q200
D5-D7 = CMP-0078196-1: as D4 on sheet PROC074A_FTDI_Interface
D8-D10 = CMP-0078197-1: LED, Red, SMD; Manufacturer: Vishay-Semiconductor; Tjmax_C: 120°C; SizeAreaWB_mm2: 4.68; Vr_V: 6V; Power_TotalModule: 40mW; Angle: 160; SizeArea_mm2: 1.28; Ir_A: 10µA; SizeZ_mm: 0.65; Io_A: 2mA; Vf_V: 1.8V; SizeY_mm: 0.8; U/M: EA; Value1: .04W; SizeX_mm: 1.6; Type: AlInGaP
J2 = CMP-0075352-1: as J1 on sheet PROC074A_CAN_Interface
L7 = CMP-0058739-1: Inductor, Multilayer, Ferrite, 1 uH, 0.8 A, 0.19 ohm, SMD; Manufacturer: MuRata; Irms: 0.8A @ 40C rise; Green_Lifecycle: Active; SizeAreaWB_mm2: 6.75; DCR_ohm: 1.9d; Green_REACh: Passed; Value: 1uH; Imax_A: 8dA; SizeZ_mm: 1.45; SizeX_mm: 2; SizeY_mm: 1.25; Value2: 0.8A; SizeArea_mm2: 2.5; Ind_H: 1µH; AEC Category: Q200
R10 R251-R253 = CMP-0078212-1: as R191 on sheet PROC074A_FTDI_Interface
R11 R31 = CMP-0026491-2: RES, 61.9, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 61R9; Value: 61.9; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R12 = CMP-0026992-2: as R3 on sheet PROC074A_CAN_Interface
R15 R32 = CMP-0026992-3: as R184 on sheet PROC074A_FTDI_Interface
R33 = CMP-0026992-3: as R1 on sheet PROC074A_CAN_Interface
R254 = CMP-0026857-5: RES, 1.6 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 1k60; Value: 1.6k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R255 = CMP-0026542-2: RES, 750, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 750R; Value: 750; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R256 = CMP-0018573-3: RES, 0, 5%, 0.25 W, AEC-Q200 Grade 0, 1206; Manufacturer: Vishay-Dale; Power_W: 250mW; TempCo: 200 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 3.2; SizeY_mm: 1.6; SizeZ_mm: 1.35; Value2: 0.25W; SizeArea_mm2: 5.12; AEC Qualified: Y; VDC_V: 200V; AEC Category: Q200
U3 = CMP-0033299-1: 5 V CAN Transceiver with I/O Level Shifting and Supply Optimization, 70 mA, 4.75 to 5.25 V, -40 to 125 degC, 8-pin SOIC (D), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; Drivers Per Package: 1; Low Power Mode: Yes; ICC(Max)(mA): 70; Bus Fault Voltage(V): -27 to 40; Rating: Catalog
U12 = CMP-0067209-5: 5V, 400mA, 4MHz Step-Up DC/DC Converter, DRV0006A (WSON-6); Manufacturer: Texas Instruments; Alternate PartNumber: TPS61240DRVT; SizeX_mm: 2; CompType: IC; SizeZ_mm: 0.8; SizeArea_mm2: 4; SizeAreaWB_mm2: 9; U/M: EA; Green_Lifecycle: Active; Green_REACh: Passed

## Sheet PROC074A_Analog_Mux_1A.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 19; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C27  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C72  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C73  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C92  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C93  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C94  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
R16  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R17  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R25  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R26  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R63  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R66  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R151  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R203  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R209  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R250  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R338  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R339  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
U5  TS3A5018RSVR  [RSV0016A]
U10  TS3A5018RSVR  [RSV0016A]
U24  TS3A5018RSVR  [RSV0016A]
U25  TS3A5018RSVR  [RSV0016A]
U26  TS3A5018RSVR  [RSV0016A]
U27  TS3A5018RSVR  [RSV0016A]

### Ports
40PIN_CS1, 40PIN_GPI0_0, 40PIN_GPI0_1, 40PIN_GPI0_2, 40PIN_HOSTINTR1, 40PIN_MCU_SOP0, 40PIN_MCU_SOP1, 40PIN_MCU_SOP2, 40PIN_MISO1, 40PIN_MOSI1, 40PIN_NERR_OUT, 40PIN_NERRIN, 40PIN_NRST, 40PIN_RS232RX, 40PIN_RS232TX, 40PIN_SPI_CLK1, 60PIN_CS1, 60PIN_HOSTINTR1, 60PIN_MISO1, 60PIN_MOSI1, 60PIN_NRST, 60PIN_RS232RX, 60PIN_RS232TX, 60PIN_SPICLK1, FTDI_60PIN_40PIN_NRST, FTDI_CLK1, FTDI_CS1, FTDI_GPIO_0, FTDI_GPIO_1, FTDI_GPIO_2, FTDI_HOST_INTR1, FTDI_MISO1, FTDI_MOSI1, FTDI_NERR_OUT, FTDI_NERRIN, FTDI_NRST, FTDI_PMIC_OUT_SOR0, FTDI_RS232RX, FTDI_RS232TX, FTDI_SYNC_OUT_SOR1, FTDI_TDO_SOR2, MCU_SOP0, MCU_SOP1, MCU_SOP2, MUX1_RS232RX, MUX1_RS232TX, MUX_CS1, MUX_HOSTINTR1, MUX_IN_1 (in), MUX_IN_2 (in), MUX_IN_3 (in), MUX_IN_4 (in), MUX_IN_6 (in), MUX_IN_7 (in), MUX_MISO1, MUX_MOSI1, MUX_NRST, MUX_RS232RX, MUX_RS232TX, MUX_SPI_CLK1, RADAR_GPIO_0, RADAR_GPIO_1, RADAR_GPIO_2, RADAR_HOSTINTR1, RADAR_NERR_IN, RADAR_NERR_OUT, SPI_CLK1, SPI_CS1, SPI_MISO1, SPI_MOSI1

### Nets
BRD_3V3: C27.1 C72.1 C73.1 C92.1 C93.1 C94.1 R25.2 R26.2 R151.2 R203.2 R209.2 R250.2 U5.14(V+) U10.14(V+) U24.14(V+) U25.14(V+) U26.14(V+) U27.14(V+)
GND: C27.2 C72.2 C73.2 C92.2 C93.2 C94.2 R16.1 R17.1 R63.1 R66.1 R338.1 R339.1 U5.6(GND) U10.6(GND) U24.6(GND) U25.6(GND) U26.6(GND) U27.6(GND)
40PIN_CS1: U24.12(NC4) ; port 40PIN_CS1
40PIN_GPI0_0: U26.1(NO1) ; port 40PIN_GPI0_0
40PIN_GPI0_1: U26.4(NO2) ; port 40PIN_GPI0_1
40PIN_GPI0_2: U26.8(NO3) ; port 40PIN_GPI0_2
40PIN_HOSTINTR1: U25.16(NC1) ; port 40PIN_HOSTINTR1
40PIN_MCU_SOP0: U27.1(NO1) ; port 40PIN_MCU_SOP0
40PIN_MCU_SOP1: U27.4(NO2) ; port 40PIN_MCU_SOP1
40PIN_MCU_SOP2: U27.8(NO3) ; port 40PIN_MCU_SOP2
40PIN_MISO1: U24.9(NC3) ; port 40PIN_MISO1
40PIN_MOSI1: U24.3(NC2) ; port 40PIN_MOSI1
40PIN_NERR_OUT: U26.11(NO4) ; port 40PIN_NERR_OUT
40PIN_NERRIN: U27.11(NO4) ; port 40PIN_NERRIN
40PIN_NRST: U25.3(NC2) ; port 40PIN_NRST
40PIN_RS232RX: U25.12(NC4) ; port 40PIN_RS232RX
40PIN_RS232TX: U25.9(NC3) ; port 40PIN_RS232TX
40PIN_SPI_CLK1: U24.16(NC1) ; port 40PIN_SPI_CLK1
60PIN_CS1: U24.11(NO4) ; port 60PIN_CS1
60PIN_HOSTINTR1: U25.1(NO1) ; port 60PIN_HOSTINTR1
60PIN_MISO1: U24.8(NO3) ; port 60PIN_MISO1
60PIN_MOSI1: U24.4(NO2) ; port 60PIN_MOSI1
60PIN_NRST: U25.4(NO2) ; port 60PIN_NRST
60PIN_RS232RX: U25.11(NO4) ; port 60PIN_RS232RX
60PIN_RS232TX: U25.8(NO3) ; port 60PIN_RS232TX
60PIN_SPICLK1: U24.1(NO1) ; port 60PIN_SPICLK1
FTDI_60PIN_40PIN_NRST: U5.5(COM2) ; port FTDI_60PIN_40PIN_NRST
FTDI_CLK1: U10.16(NC1) ; port FTDI_CLK1
FTDI_CS1: U10.12(NC4) ; port FTDI_CS1
FTDI_GPIO_0: U26.16(NC1) ; port FTDI_GPIO_0
FTDI_GPIO_1: U26.3(NC2) ; port FTDI_GPIO_1
FTDI_GPIO_2: U26.9(NC3) ; port FTDI_GPIO_2
FTDI_HOST_INTR1: U5.16(NC1) ; port FTDI_HOST_INTR1
FTDI_MISO1: U10.9(NC3) ; port FTDI_MISO1
FTDI_MOSI1: U10.3(NC2) ; port FTDI_MOSI1
FTDI_NERR_OUT: U26.12(NC4) ; port FTDI_NERR_OUT
FTDI_NERRIN: U27.12(NC4) ; port FTDI_NERRIN
FTDI_NRST: U5.3(NC2) ; port FTDI_NRST
FTDI_PMIC_OUT_SOR0: U27.16(NC1) ; port FTDI_PMIC_OUT_SOR0
FTDI_RS232RX: U5.12(NC4) ; port FTDI_RS232RX
FTDI_RS232TX: U5.9(NC3) ; port FTDI_RS232TX
FTDI_SYNC_OUT_SOR1: U27.3(NC2) ; port FTDI_SYNC_OUT_SOR1
FTDI_TDO_SOR2: U27.9(NC3) ; port FTDI_TDO_SOR2
MCU_SOP0: U27.7(COM3) ; port MCU_SOP0
MCU_SOP1: U27.5(COM2) ; port MCU_SOP1
MCU_SOP2: U27.2(COM1) ; port MCU_SOP2
MUX1_RS232RX: U5.10(COM4) ; port MUX1_RS232RX
MUX1_RS232TX: U5.7(COM3) ; port MUX1_RS232TX
MUX_CS1: U10.11(NO4) U24.10(COM4) ; port MUX_CS1
MUX_HOSTINTR1: U5.1(NO1) U25.2(COM1) ; port MUX_HOSTINTR1
MUX_IN_1: R25.1 U10.15(IN) ; port MUX_IN_1
MUX_IN_2: R26.1 U5.15(IN) ; port MUX_IN_2
MUX_IN_3: R209.1 U26.15(IN) ; port MUX_IN_3
MUX_IN_4: R250.1 U27.15(IN) ; port MUX_IN_4
MUX_IN_6: R151.1 U25.15(IN) ; port MUX_IN_6
MUX_IN_7: R203.1 U24.15(IN) ; port MUX_IN_7
MUX_MISO1: U10.8(NO3) U24.7(COM3) ; port MUX_MISO1
MUX_MOSI1: U10.4(NO2) U24.5(COM2) ; port MUX_MOSI1
MUX_NRST: U5.4(NO2) U25.5(COM2) ; port MUX_NRST
MUX_RS232RX: U5.11(NO4) U25.10(COM4) ; port MUX_RS232RX
MUX_RS232TX: U5.8(NO3) U25.7(COM3) ; port MUX_RS232TX
MUX_SPI_CLK1: U10.1(NO1) U24.2(COM1) ; port MUX_SPI_CLK1
RADAR_GPIO_0: U26.2(COM1) ; port RADAR_GPIO_0
RADAR_GPIO_1: U26.5(COM2) ; port RADAR_GPIO_1
RADAR_GPIO_2: U26.7(COM3) ; port RADAR_GPIO_2
RADAR_HOSTINTR1: U5.2(COM1) ; port RADAR_HOSTINTR1
RADAR_NERR_IN: U27.10(COM4) ; port RADAR_NERR_IN
RADAR_NERR_OUT: U26.10(COM4) ; port RADAR_NERR_OUT
SPI_CLK1: U10.2(COM1) ; port SPI_CLK1
SPI_CS1: U10.10(COM4) ; port SPI_CS1
SPI_MISO1: U10.7(COM3) ; port SPI_MISO1
SPI_MOSI1: U10.5(COM2) ; port SPI_MOSI1
NetR16_2: R16.2 U10.13(~{EN})
NetR17_2: R17.2 U5.13(~{EN})
NetR63_2: R63.2 U24.13(~{EN})
NetR66_2: R66.2 U25.13(~{EN})
NetR338_2: R338.2 U26.13(~{EN})
NetR339_2: R339.2 U27.13(~{EN})

### Notes on the sheet
- ANALOG MUX BETWEEN FTDI , DCA & 40PIN HDR 1/2
- MUX IN CONFIG
- S1.6 OFF    : 40PIN/60PIN
- S1.6 ON     : FTDI
- S1.7 OFF    : 40PIN/60PIN
- S1.7 ON     : FTDI
- S1.8 OFF     : 60PIN
- S1.8 ON      : 40PIN
- S1.10 OFF     : 40PIN
- S1.10 ON      : FTDI
- S1.11 OFF     : 40PIN
- S1.11 ON      : FTDI
- EN
- IN
- NO to COM/
- NC to COM/
- S1.9 OFF      : 60PIN
- S1.9 ON        : 40PIN
- L
- COM to NO
- OFF
- COM to NC
- ON
- H
- X

### Library data of the parts
C27 C72 C73 C92-C94 = CMP-0078241-1: as C4 on sheet PROC074A_CAN_Interface
R16 R17 R63 R66 R338 R339 = CMP-0026938-5: as R261 on sheet PROC074A_CAN_Interface
R25 R26 R151 R203 R209 R250 = CMP-0025958-2: as R5 on sheet PROC074A_CAN_Interface
U5 U10 U24-U27 = CMP-0067415-1: as U2 on sheet PROC074A_CAN_Interface