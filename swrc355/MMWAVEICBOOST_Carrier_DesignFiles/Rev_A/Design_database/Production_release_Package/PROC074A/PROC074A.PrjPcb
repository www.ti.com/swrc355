# Altium project PROC074A.PrjPcb (part 4 of 4)

## Sheet PROC074A_Analog_Mux_1B.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 20; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C95  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C114  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C115  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
C116  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
J14  22284033  [Molex_0022284033]
J15  22284033  [Molex_0022284033]
R18  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R19  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R23  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R24  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R62  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R65  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R68  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R262  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
S1  218-12LPST  [SW_218-12LPST]
U28  TS3A5018RSVR  [RSV0016A]
U33  TS3A5018RSVR  [RSV0016A]
U34  TS3A5018RSVR  [RSV0016A]
U35  TS3A5018RSVR  [RSV0016A]

### Ports
40PIN_BSS_LOGGER, 40PIN_MSS_LOGGER, 40PIN_SCL, 40PIN_SDA, 60PIN_SCL, 60PIN_SDA, FTDI_I2C_SCL, FTDI_I2C_SDA, FTDI_UART3_TX, FTDI_UART4_TX, I2C_SCL_SPIB_MISO_HDR, I2C_SDA_SPIB_MOSI_HDR, MUX1_MISO2, MUX1_RS232RX, MUX1_RS232TX, MUX2_MOSI2, MUX_CLK2, MUX_CS2, MUX_IN_1 (out), MUX_IN_2 (out), MUX_IN_3 (out), MUX_IN_4 (out), MUX_IN_5 (in), MUX_IN_5 (out), MUX_IN_6 (out), MUX_IN_7 (out), MUX_IN_8 (in), MUX_IN_8 (out), MUX_IN_9 (in), MUX_IN_9 (out), MUX_IN_10 (in), MUX_IN_10 (out), MUX_IN_11 (out), MUX_IN_12 (out), MUX_MISO2, MUX_MOSI2, RADAR_BSS_LOGGER_SPIB_CS, RADAR_MSS_LOGGER_SPIB_CLK, RADAR_RS232RX, RADAR_RS232TX, RADAR_SCL, RADAR_SDA, SPIB_CLK_HDR, SPIB_CS_HDR, XDS_I2C_SCL, XDS_I2C_SDA, XDS_RS232RX, XDS_RS232TX

### Nets
BRD_3V3: C95.1 C114.1 C115.1 C116.1 R18.2 R19.2 R23.2 R24.2 U28.14(V+) U33.14(V+) U34.14(V+) U35.14(V+)
GND: C95.2 C114.2 C115.2 C116.2 R62.1 R65.1 R68.1 R262.1 S1.1 S1.2 S1.3 S1.4 S1.5 S1.6 S1.7 S1.8 S1.9 S1.10 S1.11 S1.12 U28.6(GND) U33.6(GND) U34.6(GND) U35.6(GND)
40PIN_BSS_LOGGER: U33.12(NC4) ; port 40PIN_BSS_LOGGER
40PIN_MSS_LOGGER: U33.9(NC3) ; port 40PIN_MSS_LOGGER
40PIN_SCL: U33.16(NC1) ; port 40PIN_SCL
40PIN_SDA: U33.3(NC2) ; port 40PIN_SDA
60PIN_SCL: U35.1(NO1) ; port 60PIN_SCL
60PIN_SDA: U35.4(NO2) ; port 60PIN_SDA
FTDI_I2C_SCL: U34.16(NC1) ; port FTDI_I2C_SCL
FTDI_I2C_SDA: U34.3(NC2) ; port FTDI_I2C_SDA
FTDI_UART3_TX: U34.9(NC3) ; port FTDI_UART3_TX
FTDI_UART4_TX: U34.12(NC4) ; port FTDI_UART4_TX
I2C_SCL_SPIB_MISO_HDR: U33.1(NO1) ; port I2C_SCL_SPIB_MISO_HDR
I2C_SDA_SPIB_MOSI_HDR: U33.4(NO2) ; port I2C_SDA_SPIB_MOSI_HDR
MUX1_MISO2: U34.2(COM1) U35.16(NC1) ; port MUX1_MISO2
MUX1_RS232RX: U28.4(NO2) ; port MUX1_RS232RX
MUX1_RS232TX: U28.1(NO1) ; port MUX1_RS232TX
MUX2_MOSI2: U34.5(COM2) U35.3(NC2) ; port MUX2_MOSI2
MUX_CLK2: U33.7(COM3) U34.8(NO3) ; port MUX_CLK2
MUX_CS2: U33.10(COM4) U34.11(NO4) ; port MUX_CS2
MUX_IN_1: S1.19 ; port MUX_IN_1
MUX_IN_2: S1.18 ; port MUX_IN_2
MUX_IN_3: S1.15 ; port MUX_IN_3
MUX_IN_4: S1.14 ; port MUX_IN_4
MUX_IN_5: R24.1 S1.20 U28.15(IN) ; port MUX_IN_5
MUX_IN_6: S1.17 ; port MUX_IN_6
MUX_IN_7: S1.16 ; port MUX_IN_7
MUX_IN_8: R18.1 S1.23 U33.15(IN) ; port MUX_IN_8
MUX_IN_9: R19.1 S1.22 U34.15(IN) ; port MUX_IN_9
MUX_IN_10: R23.1 S1.21 U35.15(IN) ; port MUX_IN_10
MUX_IN_11: S1.24 ; port MUX_IN_11
MUX_IN_12: S1.13 ; port MUX_IN_12
MUX_MISO2: U33.2(COM1) U34.1(NO1) ; port MUX_MISO2
MUX_MOSI2: U33.5(COM2) U34.4(NO2) ; port MUX_MOSI2
MUX_SCL_SPIB_MISO: J14.1 U35.2(COM1)
MUX_SDA_SPIB_MOSI: J15.1 U35.5(COM2)
RADAR_BSS_LOGGER_SPIB_CS: U34.10(COM4) ; port RADAR_BSS_LOGGER_SPIB_CS
RADAR_MSS_LOGGER_SPIB_CLK: U34.7(COM3) ; port RADAR_MSS_LOGGER_SPIB_CLK
RADAR_RS232RX: U28.5(COM2) ; port RADAR_RS232RX
RADAR_RS232TX: U28.2(COM1) ; port RADAR_RS232TX
RADAR_SCL: J14.2 ; port RADAR_SCL
RADAR_SDA: J15.2 ; port RADAR_SDA
SPIB_CLK_HDR: U33.8(NO3) ; port SPIB_CLK_HDR
SPIB_CS_HDR: U33.11(NO4) ; port SPIB_CS_HDR
XDS_I2C_SCL: J14.3 ; port XDS_I2C_SCL
XDS_I2C_SDA: J15.3 ; port XDS_I2C_SDA
XDS_RS232RX: U28.3(NC2) ; port XDS_RS232RX
XDS_RS232TX: U28.16(NC1) ; port XDS_RS232TX
NetR62_2: R62.2 U33.13(~{EN})
NetR65_2: R65.2 U34.13(~{EN})
NetR68_2: R68.2 U35.13(~{EN})
NetR262_2: R262.2 U28.13(~{EN})

Not connected (* = marked no-connect by the designer): U28 7(COM3)* 8(NO3)* 9(NC3)* 10(COM4)* 11(NO4)* 12(NC4)*; U35 7(COM3)* 8(NO3)* 9(NC3)* 10(COM4)* 11(NO4)* 12(NC4)*

### Notes on the sheet
- ANALOG MUX BETWEEN FTDI , DCA & 40PIN HDR (2/2)
- MUX IN CONFIG
- S1.2 OFF   : J16 HEADER
- S1.2 ON     : 40PIN
- S1.3 OFF    : 40PIN/J16 HEADER
- S1.4 OFF     : 60PIN
- S1.3 ON      : FTDI
- S1.4 ON      : 40PIN/J16 HEADER/FTDI
- (near S1) OFF
- (near S1) ON
- (near J14) JUMPER CONFIG
- (1-2) CLOSED(DEFAULT) : FTDI/60PIN
- (2-3) CLOSED : XDS110
- (near J15) JUMPER CONFIG
- (near J15) (1-2) CLOSED(DEFAULT) : FTDI/60PIN
- S1.5 OFF    : 40PIN/60PIN/FTDI
- S1.5 ON     : XDS110

### Library data of the parts
C95 C114-C116 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 10V; CompType: Capacitor; Cap_F: 100nF; AEC Category: Q200
J14 J15 = CMP-0055332-1: Header, 2.54mm, 3x1, Tin, TH; Manufacturer: Molex; CNHeader: TRUE; Current_A: 4A; Shrouded: N; Gender: Male; Voltage_V: 250V; Row_Count: 1; Pitch_mm: 2.54; CT: FALSE; Cert_UL: Y
R18 R19 R23 R24 = CMP-0025958-2: RES, 10.0 k, 1%, 0.063 W, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; U/M: EA; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; VDC_V: 50V; AEC Category: Q200
R62 R65 R68 R262 = CMP-0026938-5: RES, 4.7 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 4k70; Value: 4.7k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
S1 = CMP-0084286-2: Switch, SPST, 12 Pos, 0.025 A, 24 VDC, SMD; Manufacturer: CTS Electrocomponents; SizeY_mm: 16.41; SizeArea_mm2: 138.5004; SizeX_mm: 8.44; CurrentRating_mA: 25A; VDC_V: 24V; SwitchFunction: Off-On; SizeZ_mm: 2.65; PositionCount: 12; SizeAreaWB_mm2: 192.2004
U28 U33-U35 = CMP-0067415-1: 10-Ohm Quad SPDT Analog Switch, RSV0016A (UQFN-16); Alternate Manufacturer: Texas Instruments; SizeAreaWB_mm2: 10.08; U/M: EA; SizeZ_mm: 0.55; SizeX_mm: 1.8; SizeY_mm: 2.6; SizeArea_mm2: 4.68; CompType: IC

## Sheet PROC074A_HD_Connector_DCA.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 21; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
J9  QSH-030-01-L-D-A  [Samtec_QSH-030-01-X-D-A]  (value not drawn)
J10  QSH-030-01-L-D-A  [Samtec_QSH-030-01-X-D-A]  (value not drawn)
R20  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R21  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R27  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R28  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R29  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R30  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R54  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R96  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R144  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R145  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R146  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R229  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R230  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R231  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R235  ValueDisplayed: 0.002  [1206]  (hidden comment: PMR18EZPFV2L00)
R236  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R237  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R238  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R239  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R240  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R241  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R242  ValueDisplayed: 100  [0402]  (hidden comment: ERJ-2GEJ101X)
R243  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R244  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R245  ValueDisplayed: 100  [0402]  (hidden comment: ERJ-2GEJ101X)
R246  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R268  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R269  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R270  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)

### Ports
60PIN_CS1, 60PIN_HOSTINTR1, 60PIN_JTAG_TCK, 60PIN_JTAG_TDI, 60PIN_JTAG_TDO_SOP0, 60PIN_JTAG_TMS, 60PIN_MISO1, 60PIN_MOSI1, 60PIN_NRST, 60PIN_RS232RX, 60PIN_RS232TX, 60PIN_SCL, 60PIN_SDA, 60PIN_SPICLK1, DCA_SYNC_IN, MIPI60_MUX_IN, PGOOD, RADAR_DMM_CLK, RADAR_DMM_SYNC, RADAR_DP0, RADAR_DP1, RADAR_DP2, RADAR_DP3, RADAR_DP4, RADAR_DP5, RADAR_DP6, RADAR_DP7, RADAR_DP8, RADAR_DP9, RADAR_DP10, RADAR_DP11, RADAR_DP12, RADAR_DP13, RADAR_DP14, RADAR_DP15, RADAR_LVDS_0M, RADAR_LVDS_0P, RADAR_LVDS_1M, RADAR_LVDS_1P, RADAR_LVDS_2M, RADAR_LVDS_2P, RADAR_LVDS_3M, RADAR_LVDS_3P, RADAR_LVDS_CLKM, RADAR_LVDS_CLKP, RADAR_LVDS_FRCLKM, RADAR_LVDS_FRCLKP, RADAR_LVDS_VALIDM, RADAR_LVDS_VALIDP

### Nets
5V_IN: R235.2
BRD_3V3: R241.2 R242.2 R243.2 R245.1
GND: J9.16 J9.57 J9.58 J9.MP1 J9.MP2 J9.MP3 J9.MP4 J10.18 J10.24 J10.30 J10.36 J10.42 J10.48 J10.54 J10.60 J10.MP1 J10.MP2 J10.MP3 J10.MP4 R244.1 R246.1
60PIN_CS1: J10.7 ; port 60PIN_CS1
60PIN_HOSTINTR1: J10.10 ; port 60PIN_HOSTINTR1
60PIN_JTAG_TCK: R240.1 ; port 60PIN_JTAG_TCK
60PIN_JTAG_TDI: R238.1 ; port 60PIN_JTAG_TDI
60PIN_JTAG_TDO_SOP0: R239.1 ; port 60PIN_JTAG_TDO_SOP0
60PIN_JTAG_TMS: R237.1 ; port 60PIN_JTAG_TMS
60PIN_MISO1: J10.12 ; port 60PIN_MISO1
60PIN_MOSI1: J10.11 ; port 60PIN_MOSI1
60PIN_NRST: J10.59 ; port 60PIN_NRST
60PIN_RS232RX: J10.55 ; port 60PIN_RS232RX
60PIN_RS232TX: J10.57 ; port 60PIN_RS232TX
60PIN_SCL: J10.53 ; port 60PIN_SCL
60PIN_SDA: J10.51 ; port 60PIN_SDA
60PIN_SPICLK1: J10.9 ; port 60PIN_SPICLK1
60PIN_VREF_JTAG: J9.1 R242.1
DCA_SYNC_IN: J10.16 ; port DCA_SYNC_IN
EMU_RSTN: J9.6 R241.1
JTAG_TGT_DET: J9.15 R246.2
JTAG_TRSTPD: J9.8 R244.2
MIPI60_JTAG_NTRST: J9.9 R243.1
MIPI60_JTAG_TCK: J9.3 R236.1 R240.2
MIPI60_JTAG_TDI: J9.5 R238.2
MIPI60_JTAG_TDO: J9.4 R239.2
MIPI60_JTAG_TMS: J9.2 R237.2
MIPI60_MUX_IN: J9.51 ; port MIPI60_MUX_IN
MIPI60_RTCK: J9.7 R236.2
MIPI60_TRACE_CTL: J9.17 R20.2
MIPI60_TRACE_D0: J9.19 R21.2
MIPI60_TRACE_D1: J9.21 R27.2
MIPI60_TRACE_D2: J9.23 R28.2
MIPI60_TRACE_D3: J9.25 R29.2
MIPI60_TRACE_D4: J9.27 R30.2
MIPI60_TRACE_D5: J9.29 R268.2
MIPI60_TRACE_D6: J9.31 R269.2
MIPI60_TRACE_D7: J9.33 R270.2
MIPI60_TRACE_D8: J9.35 R54.2
MIPI60_TRACE_D9: J9.37 R96.2
MIPI60_TRACE_D10: J9.39 R144.2
MIPI60_TRACE_D11: J9.41 R145.2
MIPI60_TRACE_D12: J9.43 R146.2
MIPI60_TRACE_D13: J9.45 R229.2
MIPI60_TRACE_D14: J9.47 R230.2
MIPI60_TRACE_D15: J9.49 R231.2
PGOOD: J10.13 ; port PGOOD
RADAR_DMM_CLK: J9.13 J10.15 ; port RADAR_DMM_CLK
RADAR_DMM_SYNC: J10.17 R20.1 ; port RADAR_DMM_SYNC
RADAR_DP0: J10.19 R21.1 ; port RADAR_DP0
RADAR_DP1: J10.21 R27.1 ; port RADAR_DP1
RADAR_DP2: J10.23 R28.1 ; port RADAR_DP2
RADAR_DP3: J10.25 R29.1 ; port RADAR_DP3
RADAR_DP4: J10.27 R30.1 ; port RADAR_DP4
RADAR_DP5: J10.29 R268.1 ; port RADAR_DP5
RADAR_DP6: J10.31 R269.1 ; port RADAR_DP6
RADAR_DP7: J10.33 R270.1 ; port RADAR_DP7
RADAR_DP8: J10.35 R54.1 ; port RADAR_DP8
RADAR_DP9: J10.37 R96.1 ; port RADAR_DP9
RADAR_DP10: J10.39 R144.1 ; port RADAR_DP10
RADAR_DP11: J10.41 R145.1 ; port RADAR_DP11
RADAR_DP12: J10.43 R146.1 ; port RADAR_DP12
RADAR_DP13: J10.45 R229.1 ; port RADAR_DP13
RADAR_DP14: J10.47 R230.1 ; port RADAR_DP14
RADAR_DP15: J10.49 R231.1 ; port RADAR_DP15
RADAR_LVDS_0M: J10.58 ; port RADAR_LVDS_0M
RADAR_LVDS_0P: J10.56 ; port RADAR_LVDS_0P
RADAR_LVDS_1M: J10.52 ; port RADAR_LVDS_1M
RADAR_LVDS_1P: J10.50 ; port RADAR_LVDS_1P
RADAR_LVDS_2M: J10.40 ; port RADAR_LVDS_2M
RADAR_LVDS_2P: J10.38 ; port RADAR_LVDS_2P
RADAR_LVDS_3M: J10.34 ; port RADAR_LVDS_3M
RADAR_LVDS_3P: J10.32 ; port RADAR_LVDS_3P
RADAR_LVDS_CLKM: J10.46 ; port RADAR_LVDS_CLKM
RADAR_LVDS_CLKP: J10.44 ; port RADAR_LVDS_CLKP
RADAR_LVDS_FRCLKM: J10.28 ; port RADAR_LVDS_FRCLKM
RADAR_LVDS_FRCLKP: J10.26 ; port RADAR_LVDS_FRCLKP
RADAR_LVDS_VALIDM: J10.22 ; port RADAR_LVDS_VALIDM
RADAR_LVDS_VALIDP: J10.20 ; port RADAR_LVDS_VALIDP
NetJ9_12: J9.12 R245.2
NetJ10_1: J10.1 J10.2 J10.3 R235.1

Not connected (* = marked no-connect by the designer): J9 10* 11* 14* 18* 20* 22* 24* 26* 28* 30* 32* 34* 36* 38* 40* 42* 44* 46* 48* 50* 52* 53* 54* 55* 56* 59* 60*; J10 4* 5* 6* 8* 14*

### Notes on the sheet
- 60PIN HD CONNECTOR FOR DCA1000
- MIPI-60 DEBUG TRACE CONNECTOR

### Library data of the parts
J9 J10 = CMP-0075524-1: Receptacle, 0.5 mm, 30x2, Gold, TH; Manufacturer: Samtec; Pitch_mm: 0.5; Gender: Female; Green_REACh: Passed; CT: False; Shrouded: N; RowSpacing_mm: 5.73; Green_Lifecycle: Active; Row_Count: 2
R20 R21 R27-R30 R54 R96 R144-R146 R229-R231 R236-R240 R246 R268-R270 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 600 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; SizeAreaWB_mm2: 3
R235 = CMP-0081623-1: RES, 0.002, 1%, 1 W, AEC-Q200 Grade 0, 1206; Manufacturer: Rohm; Value_Code: 2L000; SizeAreaWB_mm2: 10.92; SizeArea_mm2: 5.12; AEC Qualified: Y; AEC Category: Q200; Res_ohm: 2m; Value: 0.002; SizeZ_mm: 1.35; Green_REACh: Incomplete; TempCo: 100 ppm/C; AEC Grade: 0; Power_W: 1W; SizeY_mm: 1.6; Green_Lifecycle: Active; SizeX_mm: 3.2
R241 R243 R244 = CMP-0026938-5: as R62 on sheet PROC074A_Analog_Mux_1B
R242 R245 = CMP-0026993-2: RES, 100, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 200 ppm/C; Value_Code: 100R; U/M: EA; Value: 100; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; AEC Qualified: Y; AEC Grade: 0; AEC Category: Q200

## Sheet PROC074A_EVM_Hardware.SchDoc
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 1; Revision: Use project parameter SCH_Rev; SheetNumber: 22; SheetTotal: 22; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
!PCB  Printed Circuit Board  (value not drawn)  (mechanical)
CAUTION_HOT_SURFACE1  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
FID1  Fiducial  [Fiducial10-20]  (value not drawn)
FID2  Fiducial  [Fiducial10-20]  (value not drawn)
FID3  Fiducial  [Fiducial10-20]  (value not drawn)
FID4  Fiducial  [Fiducial10-20]  (value not drawn)
FID5  Fiducial  [Fiducial10-20]  (value not drawn)
FID6  Fiducial  [Fiducial10-20]  (value not drawn)
H1  RM3X6MM 2701  (mechanical)
H2  RM3X6MM 2701  (mechanical)
H3  RM3X6MM 2701  (mechanical)
H4  RM3X6MM 2701  (mechanical)
H5  24395  (mechanical)
H6  24395  (mechanical)
H7  24395  (mechanical)
H8  24395  (mechanical)
H9  MFW030A  (mechanical)
H10  MFW030A  (mechanical)
H11  MFW030A  (mechanical)
H12  MFW030A  (mechanical)
LBL1  THT-14-423-10  Note: Size: 0.65" x 0.20 "  [Label_650x200]
Logo1  Texas Instruments  [TI_Stacked_Overlay_Small]  (no BOM)
Logo2  CE Mark  [CE_Mark_5mm]  (no BOM)
Logo3  FCC disclaimer  [FCC_disclaimer]  (no BOM)
Logo4  WEEE logo  [WEEE_Minimum]  (no BOM)
SH-J1  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J2  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J3  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J4  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J5  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J6  M7582-05  [Harwin_M7582-05]  (mechanical)
SH-J7  M7582-05  [Harwin_M7582-05]  (mechanical)
ZZ1  This Assembly Note is for PCB labels only  [AssemblyNoteLabel]  (no BOM)
ZZ2  These assemblies are ESD sensitive, ESD precautions shall be observed.  [AssemblyNote]  (no BOM)
ZZ3  These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable.  [AssemblyNote]  (no BOM)
ZZ4  These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified.  [AssemblyNote]  (no BOM)

### Notes on the sheet
- Open Top Jumper Sockets
- Variant
- 001
- Variant/Label Table
- Label Text
- MMWAVEICBOOST
- (near ZZ4) HW Assembly Instructions
- 1.Mount the optional nuts and washers to mate with Starter Kit
- 3.Connect the 60pin samtec cable from MMWAVEICBOOST(J10) to DCA1000EVM(J3)
- 2.Mount the 6 quantity of stand offs,6 qty of washers and 6 qty of pan head screws to mate with DCA1000EVM

### Library data of the parts
!PCB = CMP-0003618-2: Manufacturer: Any; PartNumber: PROC074
CAUTION_HOT_SURFACE1 = CMP-0074837-1: IEC 61010-1 Hot Surface Warning; Library Reference: IEC_HotSurface; SymbolCreator: a0412235
FID1-FID6 = CMP-0077181-1: Fiducial mark.  There is nothing to buy or mount.
H1-H4 = CMP-0077936-1: MACHINE SCREW PAN PHILLIPS M3; Manufacturer: APM HEXSEAL; CompType: Standoff
H5-H8 = CMP-0084033-1: HEX STANDOFF M3 BRASS 15MM; Manufacturer: Keystone; CompType: Hardware
H9-H12 = CMP-0003900-1: WASHER FLAT M3 NYLON; Manufacturer: Essentra Components
LBL1 = CMP-0003625-1: Thermal Transfer Printable Labels, 0.650" W x 0.200" H - 10,000 per roll; Manufacturer: Brady; CompType: Label
Logo1 = CMP-0074838-1: Texas Instrument Corporate Signature; SymbolCreator: a0412235; Lib Reference: TI_Logo; Library Reference: Logo
Logo2 = CMP-0074844-1: SymbolCreator: a0412235
Logo3 = CMP-0074847-1: FCC_disclaimer; Library Reference: Logo
Logo4 = CMP-0074769-1
SH-J1-SH-J7 = CMP-0078738-1: Single Operation 2.54mm Pitch Open Top Jumper Socket; Manufacturer: Harwin; CompType: Shunt
ZZ1 = CMP-0003616-3
ZZ2 = CMP-0077236-1
ZZ3 = CMP-0077237-1
ZZ4 = CMP-0077238-1

## Nets that join several sheets
5V_IN: PROC074A_PWR_RST_LEDs (R114.2 R116.2 R118.2 R125.2), PROC074A_PWR_INPUT_REG (8 pins), PROC074A_Current_Sensors (20 pins), PROC074A_LP8752J_PMIC (11 pins), PROC074A_LP_Connector (R59.2), PROC074A_HD_Conn_JTAG_HDR (J4.2 R232.2), PROC074A_CAN_Interface (R3.2), PROC074A_CAN_Interface_LEDs (R33.1), PROC074A_HD_Connector_DCA (R235.2)
BP_LP_3V3: PROC074A_LP_Connector (R122.2), PROC074A_FTDI_Interface_PWR (J13.3)
BRD_3V3: PROC074A_PWR_RST_LEDs (5 pins), PROC074A_PWR_INPUT_REG (R291.2), PROC074A_Current_Sensors (U11.9 U20.9), PROC074A_LP8752J_PMIC (R106.1 R289.2), PROC074A_LP_Connector (7 pins), PROC074A_BP_LP_RNR_Options (8 pins), PROC074A_HD_Conn_JTAG_HDR (8 pins), PROC074A_XDS110_Interface_1A (C28.1 R147.1 U6.1), PROC074A_CAN_Interface (10 pins), PROC074A_SOP_Selection (P4.2 P5.2 P6.2), PROC074A_Temp_Sensor (5 pins), PROC074A_FTDI_Interface_PWR (J13.2), PROC074A_CAN_Interface_LEDs (C71.1 R15.2 R255.2 R256.1), PROC074A_Analog_Mux_1A (18 pins), PROC074A_Analog_Mux_1B (12 pins), PROC074A_HD_Connector_DCA (R241.2 R242.2 R243.2 R245.1)
CB_PMIC_1V0: PROC074A_Current_Sensors (U23.9), PROC074A_LP8752J_PMIC (R288.2), PROC074A_HD_Conn_JTAG_HDR (J4.1 J4.3)
CB_PMIC_1V2: PROC074A_Current_Sensors (U22.9), PROC074A_LP8752J_PMIC (R287.2), PROC074A_HD_Conn_JTAG_HDR (J4.5 J4.7)
CB_PMIC_1V8: PROC074A_Current_Sensors (U21.9), PROC074A_LP8752J_PMIC (R286.2), PROC074A_HD_Conn_JTAG_HDR (J4.9)
FTDI_3V3: PROC074A_FTDI_Interface (10 pins), PROC074A_FTDI_Interface_PWR (10 pins)
FTDI_VBUS: PROC074A_FTDI_Interface_PWR (6 pins), PROC074A_CAN_Interface_LEDs (R254.2)
GND: PROC074A_PWR_RST_LEDs (14 pins), PROC074A_PWR_INPUT_REG (61 pins), PROC074A_Current_Sensors (15 pins), PROC074A_LP8752J_PMIC (24 pins), PROC074A_LP_Connector (7 pins), PROC074A_BP_LP_RNR_Options (J16.5 R69.1 R248.1), PROC074A_HD_Conn_JTAG_HDR (45 pins), PROC074A_XDS110_Interface_1A (20 pins), PROC074A_XDS110_Interface_1B (21 pins), PROC074A_CAN_Interface (14 pins), PROC074A_SOP_Selection (R135.1 R139.1 R143.1), PROC074A_Temp_Sensor (5 pins), PROC074A_FTDI_Interface (24 pins), PROC074A_FTDI_Interface_PWR (19 pins), PROC074A_CAN_Interface_LEDs (17 pins), PROC074A_Analog_Mux_1A (18 pins), PROC074A_Analog_Mux_1B (24 pins), PROC074A_HD_Connector_DCA (21 pins)
MCU_5V: PROC074A_PWR_INPUT_REG (C111.1 R50.1 R113.1 R368.2), PROC074A_LP_Connector (J5.2 J7.3 R59.1)
PMIC_1V0: PROC074A_Current_Sensors (U23.8 U23.10), PROC074A_LP8752J_PMIC (C15.2 L3.2 R288.1 U4.1)
PMIC_1V2: PROC074A_Current_Sensors (U22.8 U22.10), PROC074A_LP8752J_PMIC (C14.2 L2.2 R287.1 U4.14)
PMIC_1V8: PROC074A_Current_Sensors (U21.8 U21.10), PROC074A_LP8752J_PMIC (C16.2 L4.2 R286.1 U4.21)
PMIC_3V3: PROC074A_Current_Sensors (U20.10), PROC074A_LP8752J_PMIC (C13.2 L1.2 R289.1 U4.8)
UNREG_IN1: PROC074A_PWR_RST_LEDs (P3.1), PROC074A_PWR_INPUT_REG (12 pins)
UNREG_IN2: PROC074A_PWR_RST_LEDs (P7.1), PROC074A_PWR_INPUT_REG (12 pins)
VCC_3V3: PROC074A_PWR_INPUT_REG (9 pins), PROC074A_Current_Sensors (U11.8 U11.10 U20.8)
VCC_XDS_3V3: PROC074A_XDS110_Interface_1A (10 pins), PROC074A_XDS110_Interface_1B (20 pins)
VDDC_1: PROC074A_XDS110_Interface_1A (C33.2 C39.2 C40.2 C41.2), PROC074A_XDS110_Interface_1B (U8.87 U8.115)
VPP_1P7: PROC074A_HD_Conn_JTAG_HDR (J17.4), PROC074A_CAN_Interface (P1.1)
XDSET_1_VBUS: PROC074A_XDS110_Interface_1A (R152.2 R154.2 U7.6), PROC074A_XDS110_Interface_1B (R159.2)
3V3_PG: PROC074A_PWR_INPUT_REG (R272.2 U13.19), PROC074A_BP_LP_RNR_Options (R398.2)
40PIN_BSS_LOGGER: PROC074A_LP_Connector (R88.1), PROC074A_Analog_Mux_1B (U33.12)
40PIN_CS1: PROC074A_LP_Connector (R64.1 R72.2), PROC074A_Analog_Mux_1A (U24.12)
40PIN_DSS_LOGGER: PROC074A_LP_Connector (J6.4), PROC074A_BP_LP_RNR_Options (R362.2)
40PIN_GPI0_0: PROC074A_LP_Connector (R79.1), PROC074A_Analog_Mux_1A (U26.1)
40PIN_GPI0_1: PROC074A_LP_Connector (R76.2), PROC074A_Analog_Mux_1A (U26.4)
40PIN_GPI0_2: PROC074A_LP_Connector (R92.2), PROC074A_Analog_Mux_1A (U26.8)
40PIN_HOSTINTR1: PROC074A_LP_Connector (R91.2 R95.2), PROC074A_Analog_Mux_1A (U25.16)
40PIN_MCU_SOP0: PROC074A_LP_Connector (R94.1), PROC074A_Analog_Mux_1A (U27.1)
40PIN_MCU_SOP1: PROC074A_LP_Connector (R93.1), PROC074A_Analog_Mux_1A (U27.4)
40PIN_MCU_SOP2: PROC074A_LP_Connector (R90.1), PROC074A_Analog_Mux_1A (U27.8)
40PIN_MCUCLKOUT: PROC074A_LP_Connector (J6.5), PROC074A_BP_LP_RNR_Options (R360.2)
40PIN_MISO1: PROC074A_LP_Connector (R89.2 R393.2), PROC074A_Analog_Mux_1A (U24.9)
40PIN_MOSI1: PROC074A_LP_Connector (R85.2 R394.2), PROC074A_Analog_Mux_1A (U24.3)
40PIN_MSS_LOGGER: PROC074A_LP_Connector (R81.1), PROC074A_Analog_Mux_1B (U33.9)
40PIN_NERR_OUT: PROC074A_LP_Connector (R67.1), PROC074A_Analog_Mux_1A (U26.11)
40PIN_NERRIN: PROC074A_LP_Connector (R60.1 R70.1), PROC074A_Analog_Mux_1A (U27.11)
40PIN_NRST: PROC074A_LP_Connector (R78.2), PROC074A_Analog_Mux_1A (U25.3)
40PIN_PMIC_CLKOUT_SOP2: PROC074A_LP_Connector (J5.20), PROC074A_BP_LP_RNR_Options (R349.2)
40PIN_PMIC_EN: PROC074A_LP_Connector (J5.16), PROC074A_BP_LP_RNR_Options (R353.2)
40PIN_RS232RX: PROC074A_LP_Connector (J5.7 R56.1), PROC074A_Analog_Mux_1A (U25.12)
40PIN_RS232TX: PROC074A_LP_Connector (J5.5 R55.1), PROC074A_Analog_Mux_1A (U25.9)
40PIN_SCL: PROC074A_LP_Connector (R57.1 R82.1), PROC074A_Analog_Mux_1B (U33.16)
40PIN_SDA: PROC074A_LP_Connector (R58.1 R86.1), PROC074A_Analog_Mux_1B (U33.3)
40PIN_SPI_CLK1: PROC074A_LP_Connector (R77.1), PROC074A_Analog_Mux_1A (U24.16)
40PIN_SYNC_IN: PROC074A_LP_Connector (J5.9), PROC074A_BP_LP_RNR_Options (R348.2)
40PIN_SYNC_OUT_SOP1: PROC074A_LP_Connector (J5.18), PROC074A_BP_LP_RNR_Options (R351.2)
40PIN_WARMRST: PROC074A_LP_Connector (J6.11 R61.1), PROC074A_BP_LP_RNR_Options (R358.2)
60PIN_CS1: PROC074A_Analog_Mux_1A (U24.11), PROC074A_HD_Connector_DCA (J10.7)
60PIN_HOSTINTR1: PROC074A_Analog_Mux_1A (U25.1), PROC074A_HD_Connector_DCA (J10.10)
60PIN_JTAG_TCK: PROC074A_HD_Conn_JTAG_HDR (J4.15 U36.2), PROC074A_HD_Connector_DCA (R240.1)
60PIN_JTAG_TDI: PROC074A_HD_Conn_JTAG_HDR (J4.11 U36.7), PROC074A_HD_Connector_DCA (R238.1)
60PIN_JTAG_TDO_SOP0: PROC074A_HD_Conn_JTAG_HDR (J4.17 U36.10), PROC074A_SOP_Selection (R141.1), PROC074A_HD_Connector_DCA (R239.1)
60PIN_JTAG_TMS: PROC074A_HD_Conn_JTAG_HDR (J4.13 U36.5), PROC074A_HD_Connector_DCA (R237.1)
60PIN_MISO1: PROC074A_Analog_Mux_1A (U24.8), PROC074A_HD_Connector_DCA (J10.12)
60PIN_MOSI1: PROC074A_Analog_Mux_1A (U24.4), PROC074A_HD_Connector_DCA (J10.11)
60PIN_NRST: PROC074A_Analog_Mux_1A (U25.4), PROC074A_HD_Connector_DCA (J10.59)
60PIN_PGOOD_3V3: PROC074A_LP_Connector (R224.2), PROC074A_HD_Conn_JTAG_HDR (J4.14)
60PIN_RS232RX: PROC074A_Analog_Mux_1A (U25.11), PROC074A_HD_Connector_DCA (J10.55)
60PIN_RS232TX: PROC074A_Analog_Mux_1A (U25.8), PROC074A_HD_Connector_DCA (J10.57)
60PIN_SCL: PROC074A_Analog_Mux_1B (U35.1), PROC074A_HD_Connector_DCA (J10.53)
60PIN_SDA: PROC074A_Analog_Mux_1B (U35.4), PROC074A_HD_Connector_DCA (J10.51)
60PIN_SPICLK1: PROC074A_Analog_Mux_1A (U24.1), PROC074A_HD_Connector_DCA (J10.9)
CAN2_RX: PROC074A_CAN_Interface (U2.9), PROC074A_CAN_Interface_LEDs (U3.4)
CAN2_TX: PROC074A_CAN_Interface (U2.12), PROC074A_CAN_Interface_LEDs (U3.1)
DCA_SYNC_IN: PROC074A_BP_LP_RNR_Options (R346.2), PROC074A_HD_Connector_DCA (J10.16)
DMM_MUX_IN: PROC074A_BP_LP_RNR_Options (R281.2), PROC074A_HD_Conn_JTAG_HDR (J18.1)
EECLK: PROC074A_FTDI_Interface (U15.62), PROC074A_FTDI_Interface_PWR (R185.1 U14.2)
EECS: PROC074A_FTDI_Interface (U15.63), PROC074A_FTDI_Interface_PWR (R186.1 U14.1)
EEDATA: PROC074A_FTDI_Interface (U15.61), PROC074A_FTDI_Interface_PWR (R187.1 R193.1 U14.3)
FTDI_60PIN_40PIN_NRST: PROC074A_PWR_RST_LEDs (R124.1), PROC074A_Analog_Mux_1A (U5.5)
FTDI_CLK1: PROC074A_FTDI_Interface (R182.2), PROC074A_Analog_Mux_1A (U10.16)
FTDI_CS1: PROC074A_FTDI_Interface (R188.2), PROC074A_Analog_Mux_1A (U10.12)
FTDI_DSS_LOGGER: PROC074A_BP_LP_RNR_Options (R361.2), PROC074A_FTDI_Interface (R192.2 R210.2)
FTDI_GPIO_0: PROC074A_FTDI_Interface (R215.2), PROC074A_Analog_Mux_1A (U26.16)
FTDI_GPIO_1: PROC074A_FTDI_Interface (R216.2), PROC074A_Analog_Mux_1A (U26.3)
FTDI_GPIO_2: PROC074A_FTDI_Interface (R217.2), PROC074A_Analog_Mux_1A (U26.9)
FTDI_HOST_INTR1: PROC074A_FTDI_Interface (R198.2 R199.2), PROC074A_Analog_Mux_1A (U5.16)
FTDI_I2C_SCL: PROC074A_FTDI_Interface (R189.1 R194.2), PROC074A_Analog_Mux_1B (U34.16)
FTDI_I2C_SDA: PROC074A_FTDI_Interface (R190.1 R195.2 R196.2), PROC074A_Analog_Mux_1B (U34.3)
FTDI_MISO1: PROC074A_FTDI_Interface (R184.2), PROC074A_Analog_Mux_1A (U10.9)
FTDI_MOSI1: PROC074A_FTDI_Interface (R183.2), PROC074A_Analog_Mux_1A (U10.3)
FTDI_NERR_OUT: PROC074A_FTDI_Interface (R207.2), PROC074A_Analog_Mux_1A (U26.12)
FTDI_NERRIN: PROC074A_FTDI_Interface (R206.2), PROC074A_Analog_Mux_1A (U27.12)
FTDI_NRST: PROC074A_FTDI_Interface (R208.2), PROC074A_CAN_Interface_LEDs (R253.1), PROC074A_Analog_Mux_1A (U5.3)
FTDI_PMIC_EN: PROC074A_BP_LP_RNR_Options (R356.2), PROC074A_FTDI_Interface (R197.2)
FTDI_PMIC_OUT_SOR0: PROC074A_FTDI_Interface (R212.2), PROC074A_CAN_Interface_LEDs (R10.1), PROC074A_Analog_Mux_1A (U27.16)
FTDI_RS232RX: PROC074A_FTDI_Interface (R202.2), PROC074A_Analog_Mux_1A (U5.12)
FTDI_RS232TX: PROC074A_FTDI_Interface (R205.2), PROC074A_Analog_Mux_1A (U5.9)
FTDI_SYNC_OUT_SOR1: PROC074A_FTDI_Interface (R213.2), PROC074A_CAN_Interface_LEDs (R251.1), PROC074A_Analog_Mux_1A (U27.3)
FTDI_TDO_SOR2: PROC074A_FTDI_Interface (R214.2), PROC074A_CAN_Interface_LEDs (R252.1), PROC074A_Analog_Mux_1A (U27.9)
FTDI_UART3_TX: PROC074A_FTDI_Interface (R43.2), PROC074A_Analog_Mux_1B (U34.9)
FTDI_UART4_TX: PROC074A_FTDI_Interface (R200.2 R211.2), PROC074A_Analog_Mux_1B (U34.12)
FTDI_WARMRST: PROC074A_BP_LP_RNR_Options (R357.2), PROC074A_FTDI_Interface (U15.46)
I2C_SCL_SPIB_MISO_HDR: PROC074A_BP_LP_RNR_Options (J16.3), PROC074A_Analog_Mux_1B (U33.1)
I2C_SDA_SPIB_MOSI_HDR: PROC074A_BP_LP_RNR_Options (J16.7), PROC074A_Analog_Mux_1B (U33.4)
MCU_SOP0: PROC074A_SOP_Selection (R140.2), PROC074A_Analog_Mux_1A (U27.7)
MCU_SOP1: PROC074A_SOP_Selection (R136.2), PROC074A_Analog_Mux_1A (U27.5)
MCU_SOP2: PROC074A_SOP_Selection (R132.2), PROC074A_Analog_Mux_1A (U27.2)
MIPI60_MUX_IN: PROC074A_BP_LP_RNR_Options (R283.2), PROC074A_HD_Connector_DCA (J9.51)
MUX1_RS232RX: PROC074A_Analog_Mux_1A (U5.10), PROC074A_Analog_Mux_1B (U28.4)
MUX1_RS232TX: PROC074A_Analog_Mux_1A (U5.7), PROC074A_Analog_Mux_1B (U28.1)
MUX_IN_1: PROC074A_Analog_Mux_1A (R25.1 U10.15), PROC074A_Analog_Mux_1B (S1.19)
MUX_IN_2: PROC074A_Analog_Mux_1A (R26.1 U5.15), PROC074A_Analog_Mux_1B (S1.18)
MUX_IN_3: PROC074A_Analog_Mux_1A (R209.1 U26.15), PROC074A_Analog_Mux_1B (S1.15)
MUX_IN_4: PROC074A_Analog_Mux_1A (R250.1 U27.15), PROC074A_Analog_Mux_1B (S1.14)
MUX_IN_6: PROC074A_Analog_Mux_1A (R151.1 U25.15), PROC074A_Analog_Mux_1B (S1.17)
MUX_IN_7: PROC074A_Analog_Mux_1A (R203.1 U24.15), PROC074A_Analog_Mux_1B (S1.16)
MUX_IN_11: PROC074A_CAN_Interface (R260.1 U2.15), PROC074A_Analog_Mux_1B (S1.24)
MUX_IN_12: PROC074A_HD_Conn_JTAG_HDR (R37.1 U36.15), PROC074A_Analog_Mux_1B (S1.13)
PGOOD: PROC074A_LP_Connector (R75.1 R224.1 R276.1), PROC074A_XDS110_Interface_1A (R150.1), PROC074A_FTDI_Interface_PWR (R290.2), PROC074A_HD_Connector_DCA (J10.13)
PMIC_CLK: PROC074A_LP8752J_PMIC (U4.3), PROC074A_SOP_Selection (R131.2)
PMIC_EN: PROC074A_BP_LP_RNR_Options (R353.1 R354.1 R356.1 R398.1), PROC074A_HD_Conn_JTAG_HDR (J17.11)
PMIC_PGOOD: PROC074A_LP8752J_PMIC (R106.2 R111.2), PROC074A_LP_Connector (R276.2)
RADAR_BSS_LOGGER_SPIB_CS: PROC074A_HD_Conn_JTAG_HDR (J4.43), PROC074A_XDS110_Interface_1B (R162.1), PROC074A_Analog_Mux_1B (U34.10)
RADAR_DMM_CLK: PROC074A_HD_Conn_JTAG_HDR (J4.10 R36.2), PROC074A_HD_Connector_DCA (J9.13 J10.15)
RADAR_DMM_SYNC: PROC074A_HD_Conn_JTAG_HDR (J4.8 R35.1), PROC074A_HD_Connector_DCA (J10.17 R20.1)
RADAR_DP0: PROC074A_HD_Conn_JTAG_HDR (J4.27 R38.1), PROC074A_HD_Connector_DCA (J10.19 R21.1)
RADAR_DP1: PROC074A_HD_Conn_JTAG_HDR (J4.29 R39.2), PROC074A_HD_Connector_DCA (J10.21 R27.1)
RADAR_DP2: PROC074A_HD_Conn_JTAG_HDR (J4.31 R40.1), PROC074A_HD_Connector_DCA (J10.23 R28.1)
RADAR_DP3: PROC074A_HD_Conn_JTAG_HDR (J4.33 R42.2), PROC074A_HD_Connector_DCA (J10.25 R29.1)
RADAR_DP4: PROC074A_HD_Conn_JTAG_HDR (J4.35 R45.1), PROC074A_HD_Connector_DCA (J10.27 R30.1)
RADAR_DP5: PROC074A_HD_Conn_JTAG_HDR (J4.37 R46.2), PROC074A_HD_Connector_DCA (J10.29 R268.1)
RADAR_DP6: PROC074A_HD_Conn_JTAG_HDR (J4.39 R52.1), PROC074A_HD_Connector_DCA (J10.31 R269.1)
RADAR_DP7: PROC074A_BP_LP_RNR_Options (R361.1 R362.1), PROC074A_HD_Conn_JTAG_HDR (J4.41 R53.2), PROC074A_HD_Connector_DCA (J10.33 R270.1)
RADAR_DP8: PROC074A_HD_Conn_JTAG_HDR (J17.13 R233.1), PROC074A_HD_Connector_DCA (J10.35 R54.1)
RADAR_DP9: PROC074A_HD_Conn_JTAG_HDR (J17.15 R234.2), PROC074A_HD_Connector_DCA (J10.37 R96.1)
RADAR_DP10: PROC074A_HD_Conn_JTAG_HDR (J17.17 R273.1), PROC074A_HD_Connector_DCA (J10.39 R144.1)
RADAR_DP11: PROC074A_HD_Conn_JTAG_HDR (J17.19 R294.2), PROC074A_HD_Connector_DCA (J10.41 R145.1)
RADAR_DP12: PROC074A_HD_Conn_JTAG_HDR (J17.21 R295.1), PROC074A_HD_Connector_DCA (J10.43 R146.1)
RADAR_DP13: PROC074A_HD_Conn_JTAG_HDR (J17.23 R296.2), PROC074A_HD_Connector_DCA (J10.45 R229.1)
RADAR_DP14: PROC074A_HD_Conn_JTAG_HDR (J17.25 R297.1), PROC074A_HD_Connector_DCA (J10.47 R230.1)
RADAR_DP15: PROC074A_HD_Conn_JTAG_HDR (J17.27 R298.2), PROC074A_HD_Connector_DCA (J10.49 R231.1)
RADAR_GPIO_0: PROC074A_HD_Conn_JTAG_HDR (J4.56), PROC074A_CAN_Interface (R1.2), PROC074A_Analog_Mux_1A (U26.2)
RADAR_GPIO_1: PROC074A_PWR_RST_LEDs (R121.2), PROC074A_HD_Conn_JTAG_HDR (J4.58), PROC074A_Analog_Mux_1A (U26.5)
RADAR_GPIO_2: PROC074A_PWR_RST_LEDs (R128.1 R130.2), PROC074A_HD_Conn_JTAG_HDR (J4.60), PROC074A_Analog_Mux_1A (U26.7)
RADAR_HOSTINTR1: PROC074A_BP_LP_RNR_Options (R69.2), PROC074A_HD_Conn_JTAG_HDR (J4.16), PROC074A_Analog_Mux_1A (U5.2)
RADAR_LVDS_0M: PROC074A_HD_Conn_JTAG_HDR (J4.48), PROC074A_HD_Connector_DCA (J10.58)
RADAR_LVDS_0P: PROC074A_HD_Conn_JTAG_HDR (J4.46), PROC074A_HD_Connector_DCA (J10.56)
RADAR_LVDS_1M: PROC074A_HD_Conn_JTAG_HDR (J4.42), PROC074A_HD_Connector_DCA (J10.52)
RADAR_LVDS_1P: PROC074A_HD_Conn_JTAG_HDR (J4.40), PROC074A_HD_Connector_DCA (J10.50)
RADAR_LVDS_2M: PROC074A_HD_Conn_JTAG_HDR (J17.40), PROC074A_HD_Connector_DCA (J10.40)
RADAR_LVDS_2P: PROC074A_HD_Conn_JTAG_HDR (J17.38), PROC074A_HD_Connector_DCA (J10.38)
RADAR_LVDS_3M: PROC074A_HD_Conn_JTAG_HDR (J17.34), PROC074A_HD_Connector_DCA (J10.34)
RADAR_LVDS_3P: PROC074A_HD_Conn_JTAG_HDR (J17.32), PROC074A_HD_Connector_DCA (J10.32)
RADAR_LVDS_CLKM: PROC074A_HD_Conn_JTAG_HDR (J4.36), PROC074A_HD_Connector_DCA (J10.46)
RADAR_LVDS_CLKP: PROC074A_HD_Conn_JTAG_HDR (J4.34), PROC074A_HD_Connector_DCA (J10.44)
RADAR_LVDS_FRCLKM: PROC074A_HD_Conn_JTAG_HDR (J4.30), PROC074A_HD_Connector_DCA (J10.28)
RADAR_LVDS_FRCLKP: PROC074A_HD_Conn_JTAG_HDR (J4.28), PROC074A_HD_Connector_DCA (J10.26)
RADAR_LVDS_VALIDM: PROC074A_HD_Conn_JTAG_HDR (J17.22), PROC074A_HD_Connector_DCA (J10.22)
RADAR_LVDS_VALIDP: PROC074A_HD_Conn_JTAG_HDR (J17.20), PROC074A_HD_Connector_DCA (J10.20)
RADAR_MCUCLKOUT: PROC074A_BP_LP_RNR_Options (R359.1 R360.1), PROC074A_HD_Conn_JTAG_HDR (J4.47)
RADAR_MSS_LOGGER_SPIB_CLK: PROC074A_HD_Conn_JTAG_HDR (J4.18), PROC074A_XDS110_Interface_1B (R161.1), PROC074A_Analog_Mux_1B (U34.7)
RADAR_NERR_IN: PROC074A_BP_LP_RNR_Options (R22.1), PROC074A_HD_Conn_JTAG_HDR (J4.52), PROC074A_Analog_Mux_1A (U27.10)
RADAR_NERR_OUT: PROC074A_PWR_RST_LEDs (DS3.2), PROC074A_BP_LP_RNR_Options (R274.1), PROC074A_HD_Conn_JTAG_HDR (J4.54), PROC074A_Analog_Mux_1A (U26.10)
RADAR_NRST: PROC074A_PWR_RST_LEDs (6 pins), PROC074A_HD_Conn_JTAG_HDR (J4.12)
RADAR_NRST_XDS: PROC074A_PWR_RST_LEDs (R129.1), PROC074A_XDS110_Interface_1B (U8.40)
RADAR_PMIC_CLKOUT_SOP2: PROC074A_BP_LP_RNR_Options (R347.1 R349.1), PROC074A_HD_Conn_JTAG_HDR (J4.49), PROC074A_SOP_Selection (R131.1 R133.1)
RADAR_RS232RX: PROC074A_BP_LP_RNR_Options (R247.1), PROC074A_HD_Conn_JTAG_HDR (J4.57), PROC074A_Analog_Mux_1B (U28.5)
RADAR_RS232TX: PROC074A_BP_LP_RNR_Options (R73.1), PROC074A_HD_Conn_JTAG_HDR (J4.59), PROC074A_Analog_Mux_1B (U28.2)
RADAR_SCL: PROC074A_Current_Sensors (5 pins), PROC074A_LP8752J_PMIC (R100.2), PROC074A_BP_LP_RNR_Options (R9.1), PROC074A_HD_Conn_JTAG_HDR (J4.55), PROC074A_Temp_Sensor (R171.1 R173.1), PROC074A_Analog_Mux_1B (J14.2)
RADAR_SDA: PROC074A_Current_Sensors (5 pins), PROC074A_LP8752J_PMIC (R99.2), PROC074A_BP_LP_RNR_Options (R13.1), PROC074A_HD_Conn_JTAG_HDR (J4.53), PROC074A_Temp_Sensor (R174.2 R175.2), PROC074A_Analog_Mux_1B (J15.2)
RADAR_SPI_CLK1: PROC074A_HD_Conn_JTAG_HDR (J4.21), PROC074A_CAN_Interface (U2.7)
RADAR_SPI_CS1: PROC074A_BP_LP_RNR_Options (R249.1), PROC074A_HD_Conn_JTAG_HDR (J4.19), PROC074A_CAN_Interface (U2.10)
RADAR_SPI_MISO1: PROC074A_HD_Conn_JTAG_HDR (J4.25), PROC074A_CAN_Interface (U2.2)
RADAR_SPI_MOSI1: PROC074A_HD_Conn_JTAG_HDR (J4.23), PROC074A_CAN_Interface (U2.5)
RADAR_SYNC_IN: PROC074A_BP_LP_RNR_Options (5 pins), PROC074A_HD_Conn_JTAG_HDR (J4.22)
RADAR_SYNC_OUT_SOP1: PROC074A_BP_LP_RNR_Options (R350.1 R351.1), PROC074A_HD_Conn_JTAG_HDR (J4.24), PROC074A_SOP_Selection (R137.1)
RADAR_WARMRST: PROC074A_BP_LP_RNR_Options (R275.1 R357.1 R358.1), PROC074A_HD_Conn_JTAG_HDR (J4.51)
SPI_CLK1: PROC074A_CAN_Interface (U2.8), PROC074A_Analog_Mux_1A (U10.2)
SPI_CS1: PROC074A_CAN_Interface (U2.11), PROC074A_Analog_Mux_1A (U10.10)
SPI_MISO1: PROC074A_CAN_Interface (U2.1), PROC074A_Analog_Mux_1A (U10.7)
SPI_MOSI1: PROC074A_CAN_Interface (U2.4), PROC074A_Analog_Mux_1A (U10.5)
SPIB_CLK_HDR: PROC074A_BP_LP_RNR_Options (J16.1), PROC074A_Analog_Mux_1B (U33.8)
SPIB_CS_HDR: PROC074A_BP_LP_RNR_Options (J16.9), PROC074A_Analog_Mux_1B (U33.11)
USBDM: PROC074A_FTDI_Interface (U15.7), PROC074A_FTDI_Interface_PWR (J12.2 U16.4)
USBDP: PROC074A_FTDI_Interface (U15.8), PROC074A_FTDI_Interface_PWR (J12.3 U16.1)
VBUS_1_DETECT: PROC074A_XDS110_Interface_1A (C42.2 R152.1 R155.2), PROC074A_XDS110_Interface_1B (U8.1)
XDS_I2C_SCL: PROC074A_XDS110_Interface_1B (R48.1), PROC074A_Analog_Mux_1B (J14.3)
XDS_I2C_SDA: PROC074A_XDS110_Interface_1B (R47.1), PROC074A_Analog_Mux_1B (J15.3)
XDS_RS232RX: PROC074A_XDS110_Interface_1B (R160.1), PROC074A_Analog_Mux_1B (U28.3)
XDS_RS232TX: PROC074A_XDS110_Interface_1B (R157.1), PROC074A_Analog_Mux_1B (U28.16)
XDSET_1_DM: PROC074A_XDS110_Interface_1A (J11.2 U7.4), PROC074A_XDS110_Interface_1B (U8.93)
XDSET_1_DP: PROC074A_XDS110_Interface_1A (J11.3 U7.5), PROC074A_XDS110_Interface_1B (U8.94)
XDSET_1_ID: PROC074A_XDS110_Interface_1A (J11.4 U7.2), PROC074A_XDS110_Interface_1B (R158.2)
XDSET_TCK: PROC074A_HD_Conn_JTAG_HDR (U36.16), PROC074A_XDS110_Interface_1B (U8.35)
XDSET_TDI: PROC074A_HD_Conn_JTAG_HDR (U36.9), PROC074A_XDS110_Interface_1B (U8.38)
XDSET_TDO: PROC074A_HD_Conn_JTAG_HDR (U36.12), PROC074A_XDS110_Interface_1B (U8.37)
XDSET_TMS: PROC074A_HD_Conn_JTAG_HDR (U36.3), PROC074A_XDS110_Interface_1B (U8.36)

## Assembly variants
001: not fitted C22 C23 C30 C110 C113 FB1 FID1 FID2 FID3 FID4 FID5 FID6 J9 J16 J18 J20 P1 R1 R4 R9 R13 R22 R33 R35 R36 R38 R39 R40 R42 R45 R46 R51 R52 R53 R55 R56 R57 R58 R59 R60 R61 R64 R69 R71 R73 R75 R76 R79 R80 R81 R92 R95 R107 R108 R109 R110 R113 R115 R122 R131 R147 R162 R189 R190 R192 R211 R215 R216 R217 R228 R232 R233 R234 R247 R248 R249 R273 R274 R276 R281 R283 R286 R287 R288 R289 R294 R295 R296 R297 R298 R299 R301 R317 R318 R326 R327 R330 R347 R348 R350 R353 R354 R356 R358 R360 R362 R363 R393 R394 R404