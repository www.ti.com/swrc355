# Altium PCB PROC074B-PCB_ASCII.PcbDoc (part 3 of 9)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 2755.91 x 5300 mil, 10 copper layers (Top Layer, L2-GND, L3-SIG1, L4-GND, L5-PWR/SIG, L6-SIG2, L7-PWR2, L8-SIG3, L9-GND, Bottom Layer), stack 67.57 mil thick; 585 components, 490 nets, 2137 pads, 1150 vias.

## Part data
C1 C2 C4 C27 C32 C33 C34 C36 C40 C43 C44 C45 C49 C50 C52 C54 C55 C56 C57 C59 C63 C67 C68 C70 C72 C73 C92 C93 C94 C95 C114 C115 C116 C117: library part CMP-0078241-1, "CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402"
C3 C5: library part CMP-0078221-1, "CAP, CERM, 4700 pF, 50 V,+/- 10%, X7R, 0402"
C6 C7 C8 C25 C26 C71 C74 C77: library part CMP-0006325-2, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402"
C9 C10 C11 C12: library part CMP-0081849-1, "CAP, CERM, 10 µF,  V,+/- 10%, X7R, 0805"
C13 C14 C15 C16: library part CMP-0008811-2, "CAP, CERM, 22 uF, 10 V, +/- 10%, X7R, AEC-Q200 Grade 1, 1206"
C17: library part CMP-0078265-1, "CAP, CERM, 0.22 µF, 16 V,+/- 10%, X7R, AEC-Q200 Grade 1, 0402"
C18 C19 C20 C21: library part CMP-0078223-1, "CAP, CERM, 390 pF, 50 V,+/- 5%, C0G/NP0, AEC-Q200 Grade 0, 0402"
C22 C23: library part CMP-0082253-1, "CAP, TA, 47 µF, 50 V, +/- 10%, 0.24 ohm, SMD"
C24: library part CMP-0006351-2, "CAP, CERM, 0.1 uF, 16 V, +/- 10%, X7R, 0402"
C28: library part CMP-0007111-4, "CAP, CERM, 1 uF, 6.3 V, +/- 10%, X7R, 0603"
C29: library part CMP-0007359-4, "CAP, CERM, 0.1 uF, 6.3 V, +/- 10%, X7R, 0603"
C30 C110 C113: library part CMP-0006332-2, "CAP, CERM, 1000 pF, 100 V, +/- 10%, X7S, AEC-Q200 Grade 1, 0402"
C31 C66 C69 C111: library part CMP-0007136-5, "CAP, CERM, 1 uF, 16 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0603"
C35 C37 C41 C120: library part CMP-0078222-1, "CAP, CERM, 1 µF, 6.3 V,+/- 20%, X7S, 0402"
C38: library part CMP-0078220-1, "CAP, CERM, 0.01 µF, 25 V,+/- 10%, X7R, 0402"
C39 C62 C65 C88: library part CMP-0006302-2, "CAP, CERM, 2.2 uF, 10 V, +/- 10%, X7S, 0402"
C42 C46: library part CMP-0078218-1, "CAP, CERM, 0.01 µF, 16 V,+/- 10%, X7R, 0402"
C47 C48 C60 C61: library part CMP-0006494-2, "CAP, CERM, 8 pF, 50 V, +/- 6%, C0G/NP0, 0402"
C51 C53 C58: library part CMP-0007058-4, "CAP, CERM, 4.7 uF, 10 V, +/- 10%, X7S, 0603"
C64: library part CMP-0078217-1, "CAP, CERM, 15 pF, 50 V,+/- 1%, C0G/NP0, 0402"
C75 C76: library part CMP-0006906-5, "CAP, CERM, 2.2 uF, 10 V, +/- 10%, X5R, 0603"
C78 C96: library part CMP-0006717-2, "CAP, CERM, 0.47 uF, 6.3 V, +/- 10%, X7R, 0402"
C79 C97: library part CMP-0011176-2, "CAP, AL, 10 uF, 50 V, +/- 20%, 1.52 ohm, AEC-Q200 Grade 2, SMD"
C80 C83 C98 C101: library part CMP-0009227-2, "CAP, CERM, 10 uF, 50 V, +/- 20%, X7R, 1210"
C81 C84 C99 C102: library part CMP-0009075-1, "CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, 1210"
C82 C85 C100 C103: library part CMP-0007718-2, "CAP, CERM, 0.01 uF, 50 V, +/- 10%, X7R, 0805"
C86 C104: library part CMP-0006201-2, "CAP, CERM, 0.1 uF, 16 V, +/- 10%, X7R, 0402"
C87 C108: library part CMP-0007870-2, "CAP, CERM, 4.7 uF, 25 V, +/- 10%, X7R, 0805"
C89 C90 C91 C105 C106 C107: library part CMP-0081783-1, "CAP, CERM, 22 µF, 16 V,+/- 10%, X7R, 1210"
C109 C112: library part CMP-0006856-6, "CAP, CERM, 0.1 uF, 25 V, +/- 5%, X7R, 0603"
C119: library part CMP-0006242-2, "CAP, CERM, 33 pF, 50 V, +/- 5%, C0G/NP0, 0402"
"CAUTION HOT SURFACE1": library part CMP-0074837-1, "IEC 61010-1 Hot Surface Warning"
D1: library part CMP-0005561-2, "Diode, TVS, Uni, 30 V, 48.4 Vc, SMB"
D4 D5 D6 D7 DS1 DS2: library part CMP-0078196-1, "LED, Yellow, SMD"
D8 D9 D10 DS3 DS4: library part CMP-0078197-1, "LED, Red, SMD"
D11 D14: library part CMP-0002873-1, "LED, Green, SMD"
F1: library part CMP-0003458-1, "Fuse, 5 A, 32VAC/VDC, SMD"
FB1 FB2: library part CMP-0003364-1, "Ferrite Bead, 30 ohm @ 100 MHz, 4 A, 0805"
FID1 FID2 FID3 FID4 FID5 FID6: library part CMP-0077181-1, "Fiducial mark.  There is nothing to buy or mount."
J1 J2: library part CMP-0075352-1, "Terminal Block, 3.5mm, 3x1, Tin, R/A, TH"
J3: library part CMP-0055788-1, "UMC Straight Jack Receptacle, 50 Ohm, Gold, SMT"
J4 J17: library part CMP-0075558-2, "Header(Shrouded), 19.7mil, 30x2, Gold, SMT"
J5 J6: library part CMP-0078182-1, "Receptacle, 2.54mm, 10x2, Gold with Tin tail, SMT"
J7 J8: library part CMP-0078183-1, "Receptacle, 2.54mm, 3x1, Gold with Tin tail, SMT"
J9 J10: library part CMP-0075524-1, "Receptacle, 0.5 mm, 30x2, Gold, TH"
J11 J12: library part CMP-0055293-1, "Connector, Receptacle, Micro-USB Type B, R/A, Bottom Mount SMT"
J13 J14 J15 J27 J28: library part CMP-0055332-1, "Header, 2.54mm, 3x1, Tin, TH"
J16: library part CMP-0075410-2, "Header, 100mil, 5x2, Gold, TH"
J18 J20: library part CMP-0075418-1, "Header, 100mil, 8x2, Gold, TH"
J19: library part CMP-0081507-3, "Header, 2.54mm, 13Pos, Gold with Tin tail, TH"
L1 L2 L3 L4: library part CMP-0058946-1, "Inductor, Shielded, 470 nH, 4.7 A, 0.021 ohm, SMD"
L5 L6: library part CMP-0081523-1, "Ferrite Bead, 600 ohm @ 100 MHz, 0.3 A, 0402"
L7: library part CMP-0058739-1, "Inductor, Multilayer, Ferrite, 1 uH, 0.8 A, 0.19 ohm, SMD"
L8 L9: library part CMP-0061001-1, "Inductor, Shielded, Composite, 2.2 uH, 9.2 A, 0.01 ohm, SMD"
LBL1: library part CMP-0003625-1, "Thermal Transfer Printable Labels, 0.650\" W x 0.200\" H - 10,000 per roll"
Logo1: library part CMP-0074838-1, "Texas Instrument Corporate Signature"
Logo2: library part CMP-0074844-1
Logo3: library part CMP-0074847-1, "FCC_disclaimer"
Logo4: library part CMP-0074769-1
P1 P3 P4 P5 P6 P7: library part CMP-0075405-1, "Header, 100mil, 2x1, Gold, TH"
P2: library part CMP-0078270-1, "DC POWER JACK, R/A, TH"
Q1 Q2: library part CMP-0000947-2, "MOSFET, N-CH, 100 V, 0.17 A, SOT-23"
R1 R6 R8 R15 R20 R21 R27 R28 R29 R30 R32 R33 R35 R36 R38 R39 R40 R42 R43 R44 R45 R46 R47 R48 R52 R53 R54 R75 R96 R131 R144 R145 R146 R157 R160 R181 R184 R192 R194 R195 R196 R198 R199 R200 R202 R205 R207 R210 R211 R215 R216 R217 R224 R227 R229 R230 R231 R233 R234 R236 R237 R238 R239 R240 R246 R268 R269 R270 R273 R276 R281 R283 R290 R294 R295 R296 R297 R298 R346 R347 R348 R349 R350 R351 R353 R354 R356 R357 R358 R359 R360 R361 R362 R398: library part CMP-0026992-3, "RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R2 R7: library part CMP-0026491-1, "RES, 61.9, 1%, 0.063 W, 0402"
R3 R12 R74 R80 R106 R150 R158 R179 R180: library part CMP-0026992-2, "RES, 0, 5%, 0.063 W, 0402"
R4 R5 R18 R19 R23 R24 R25 R26 R37 R51 R57 R58 R60 R61 R71 R95 R109 R110 R120 R126 R133 R137 R141 R151 R168 R176 R177 R203 R209 R250 R260 R299 R301 R307 R308 R310 R311 R314 R316 R317 R325 R327 R328 R330 R331 R332 R395 R399 R400 R401 R402: library part CMP-0025958-2, "RES, 10.0 k, 1%, 0.063 W, 0402"
R9 R13 R22 R69 R185 R186 R187 R189 R190 R201 R274 R275 R364 R369: library part CMP-0025958-3, "RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R10 R114 R117 R118 R125 R128 R191 R251 R252 R253: library part CMP-0078212-1, "RES, 510, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R11 R31: library part CMP-0026491-2, "RES, 61.9, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R14 R67 R70 R72 R76 R77 R78 R79 R81 R82 R85 R86 R88 R89 R90 R91 R92 R93 R94 R99 R100 R121 R161 R162 R171 R172 R173 R174 R175 R178 R393 R394: library part CMP-0027008-3, "RES, 0, 5%, 0.05 W, 0201"
R16 R17 R41 R62 R63 R65 R66 R68 R241 R243 R244 R261 R262 R338 R339: library part CMP-0026938-5, "RES, 4.7 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R34 R119 R124 R127 R129 R159 R242 R245 R329 R367 R368 R370: library part CMP-0026993-2, "RES, 100, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R49 R50 R122 R232 R235 R286 R287 R288 R289 R291: library part CMP-0081623-1, "RES, 0.002, 1%, 1 W, AEC-Q200 Grade 0, 1206"
R55 R56 R64 R73 R111 R130 R247 R248 R249: library part CMP-0025950-2, "RES, 100 k, 1%, 0.063 W, 0402"
R59 R113 R115 R116: library part CMP-0016044-2, "RES, 0, 5%, 0.75 W, AEC-Q200 Grade 0, 2010"
R97 R98: library part CMP-0026414-1, "RES, 4.99 k, 1%, 0.063 W, 0402"
R101 R102 R103 R104: library part CMP-0026363-1, "RES, 3.83, 1%, 0.063 W, 0402"
R105 R204: library part CMP-0078193-1, "RES, 1.0 k, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R107 R108: library part CMP-0026701-1, "RES, 4.99 k, 1%, 0.1 W, AEC-Q200 Grade 0, 0402"
R112: library part CMP-0026099-1, "RES, 1.96 k, 1%, 0.063 W, 0402"
R123: library part CMP-0078194-1, "RES, 360, 5%, 0.1 W, AEC-Q200 Grade 0, 0402"
R132 R136 R140: library part CMP-0026542-1, "RES, 750, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R134 R138 R142: library part CMP-0026557-1, "RES, 7.87 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R135 R139 R143: library part CMP-0026574-1, "RES, 82.5 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R147: library part CMP-0081973-1, "RES, 0, 0%, 0.25 W, AEC-Q200 Grade 0, 0603"
R148 R326 R363: library part CMP-0026944-3, "RES, 510, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R149: library part CMP-0026659-1, "RES, 100 k, 1%, 0.1 W, 0402"
R152 R155: library part CMP-0078210-1, "RES, 330 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R153: library part CMP-0078244-1, "RES, 30.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R154 R156: library part CMP-0025884-3, "RES, 0, 5%, 0.125 W, 0603"
R163 R164 R165 R166 R169: library part CMP-0026071-2, "RES, 1.00 k, 1%, 0.063 W, 0402"
R167: library part CMP-0026404-1, "RES, 49.9, 1%, 0.063 W, 0402"
R170: library part CMP-0026413-1, "RES, 4.87 k, 1%, 0.063 W, 0402"
R182 R183 R188 R197 R206 R208 R212 R213 R214 R218: library part CMP-0026299-2, "RES, 33.2, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R193: library part CMP-0026890-5, "RES, 2.2 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R219 R220 R221: library part CMP-0020442-3, "RES, 0, 5%, 0.125 W, AEC-Q200 Grade 0, 0805"
R222: library part CMP-0026403-2, "RES, 49.9 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R223: library part CMP-0078244-2, "RES, 30.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R225: library part CMP-0026225-2, "RES, 29.4 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R226 R228: library part CMP-0025950-3, "RES, 100 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R254: library part CMP-0026857-5, "RES, 1.6 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R255: library part CMP-0026542-2, "RES, 750, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R256: library part CMP-0018573-3, "RES, 0, 5%, 0.25 W, AEC-Q200 Grade 0, 1206"
R271 R272 R309 R312 R315 R318 R403 R404: library part CMP-0026825-5, "RES, 10 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R293: library part CMP-0026878-3, "RES, 220, 5%, 0.063 W, AEC-Q200 Grade 0, 0402"
R303 R304 R305 R306 R319 R320 R321 R322 R323 R324: library part CMP-0027008-4, "RES, 0, 5%, 0.05 W, 0201"
R313: library part CMP-0026216-2, "RES, 280, 1%, 0.063 W, AEC-Q200 Grade 0, 0402"
R396: library part CMP-0026015-2, "RES, 14.0 k, 1%, 0.063 W, 0402"
R397: library part CMP-0078213-1, "RES, 35000, 0.1%, 0.05 W, 0402"
S1: library part CMP-0084286-2, "Switch, SPST, 12 Pos, 0.025 A, 24 VDC, SMD"
SW1 SW2: library part CMP-0002325-1, "Switch, SPST-NO, Off-Mom, 0.01 A, 32 VDC, SMD"
TP1: library part CMP-0055138-1, "Test Point, Miniature, Black, TH"
U1: library part CMP-0075992-1, "Automotive Fault Protected CAN Transceiver With Flexible Data-Rate, D0008A (SOIC-8)"
U2 U5 U10 U24 U25 U26 U27 U28 U33 U34 U35 U36: library part CMP-0067415-1, "10-Ohm Quad SPDT Analog Switch, RSV0016A (UQFN-16)"
U3: library part CMP-0033299-1, "5 V CAN Transceiver with I/O Level Shifting and Supply Optimization, 70 mA, 4.75 to 5.25 V, -40 to 125 degC, 8-pin SOIC (D), Green (RoHS & no Sb/Br)"
U4: library part CMP-0079120-1, "4-A + 2.5-A + Two 1.5-A Buck Converters With Integrated Switches, RNF0026C (VQFN-HR-26)"
U6 U31 U32: library part CMP-0077265-1, "5.5-V, 2-A, 80 mohm Low Leakage Load Switch with RCB and Programmable Rise Time, DBV0006A (SOT-23-6)"
U7: library part CMP-0043115-1, "ESD-Protection Array for High-Speed Data Interfaces, 4 Channels, -40 to +85 degC, 6-pin SON (DRY), Green (RoHS & no Sb/Br)"
U8: library part CMP-0029856-2, "Tiva C Series Microcontroller, 1024 KB Flash, 256 KB SRAM, 12 Bit, 20 Channels, -40 to 105 degC, 128-Pin TQFP (PDT), Green (RoHS & no Sb/Br), Tray"
U9: library part CMP-0033001-1, "Precision Micropower Shunt Voltage Reference, 0.5% accuracy, 2.5 V, 15 ppm / degC, 15 mA, -40 to 125 degC, 3-pin SOT-23 (DBZ), Green (RoHS & no Sb/Br)"
U11 U20 U21 U22 U23: library part CMP-0037978-1, "High-Side Measurement, Bi-Directional Current / Power Monitor with I2C Interface, 2.7 to 5.5 V, -40 to 125 degC, 10-pin SOP (DGS10), Green (RoHS & no Sb/Br)"
U12: library part CMP-0067209-5, "5V, 400mA, 4MHz Step-Up DC/DC Converter, DRV0006A (WSON-6)"
U13: library part CMP-0076352-4, "3.5A, 36 V Synchronous, 2.1MHz, Automotive Step Down DC-DC Converter, RNL0022A (VQFN-HR-22)"
U14: library part CMP-0081524-1, "1K Microwire Compatible Serial EEPROM, TSSOP-8"
U15: library part CMP-0004747-1, "Quad High Speed USB to Multipurpose UART/MPSSE IC"
U16: library part CMP-0043115-2, "ESD-Protection Array for High-Speed Data Interfaces, 4 Channels, -40 to +85 degC, 6-pin SON (DRY), Green (RoHS & no Sb/Br)"
U17: library part CMP-0036402-3, "Single Output High PSRR LDO, 1 A, Adjustable 1.2 to 5.5 V Output, 2.7 to 5.5 V Input, 8-pin SON (DRB), -40 to 125 degC, Green (RoHS & no Sb/Br)"
U18 U19: library part CMP-0067397-2, "1.4V-Capable +/-0.5degC Temperature Sensor with Alert Function and I2C/SMBus interface in SOT-563, DRL0006A (SOT-OTHER-6)"
U29: library part CMP-0076347-4, "2.5A, 36 V Synchronous, 2.1MHz, Automotive Step Down DC-DC Converter, RNL0022A (VQFN-HR-22)"
U30: library part CMP-0036402-2, "Single Output High PSRR LDO, 1 A, Adjustable 1.2 to 5.5 V Output, 2.7 to 5.5 V Input, 8-pin SON (DRB), -40 to 125 degC, Green (RoHS & no Sb/Br)"
Y1: library part CMP-0078214-2, "Crystal, 16 MHz, 15 ppm, 8 pF, AEC-Q200 Grade 1, SMD"
Y2: library part CMP-0081529-1, "Crystal, 12 MHz, 15 ppm, 8 pF, AEC-Q200 Grade 1, SMD"
ZZ1: library part CMP-0003616-3
ZZ2: library part CMP-0077236-1
ZZ3: library part CMP-0077237-1
ZZ4: library part CMP-0077238-1

## Free pads (board coordinates)
  round 118.11 hole 118.11 unplated: 1(314.96,118.11) 1(2637.8,118.11)
  round 0 all layers, no hole paste+0 mask+0: 1(2684.84,1930.95)
  round 140 hole 80: 6(828.02,4871.14)
  round 157.48 hole 118.11: TH1(369.37,3879.06) TH1(369.37,4627.09) TH1(369.37,4945.76) TH1(2298.5,3879.06) TH1(2298.5,4627.09) TH1(2298.5,4945.76)

## Via types
v1: diameter 22.4, hole 12.2, Top Layer to Bottom Layer, tented both sides, 1123 vias
v2: diameter 15.75, hole 7.87, Top Layer to Bottom Layer, tented both sides, 14 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 13 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point)
3V3_MON_FTDI: R226.2 R228.1 R290.1 U17.8 | length 429.5
  Top Layer w6: U17.8@1387.48,2743.39 1496.71,2743.39 v1(1498.44,2741.66)
  Bottom Layer w10: R226.2@1208.37,2769.06 1264.76,2769.06 R228.1@1275.51,2779.81 1292.08,2763.24 1341,2763.24 1371.67,2732.57 R290.1@1400.28,2732.57 1406.97,2739.26 1496.04,2739.26 v1(1498.44,2741.66)
3V3_MON_XDS_1: R149.2 R150.2 U6.3 | length 341.5
  Bottom Layer w6: R149.2@820,2698.62 820,2725 825.98,2730.98 U6.3@825.98,2767.86 825.98,2797 839.82,2810.84 924.83,2810.84 960.19,2775.49 1025.79,2775.49 R150.2@1040.23,2789.93
3V3_PG: R272.2 R398.2 U13.19 | length 6229.7
  Top Layer w10: v1(1890.68,1188.74) U13.19@1922.56,1188.74
  Top Layer w15: v1(1777.52,954.06) R272.2@1820.75,954.06
  L6-SIG2 w10: v1(870,4425) 831.17,4386.17 831.17,4356.17 775.86,4300.86 642.51,4300.86 627.37,4316 568,4316 515,4263 515,4236 90,3811 90,2534 279,2345 279,1886 160,1767 160,1293 249,1204 249,1074 425,898 425,829 526,728 1403,728 1512.34,837.34 1707.29,837.34 1777.52,907.57 v1(1777.52,954.06)
  Bottom Layer w6: v1(1777.52,954.06) 1776.17,955.41 1776.17,1074.23 v1(1890.68,1188.74)
  Bottom Layer w8: R398.2@813.62,4423.35 868.35,4423.35 v1(870,4425)
5V_IN: C6.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C17.2 C25.2 C26.2 C109.1 C112.1 J4.2 R3.2 R33.1 R59.2 R105.2 R113.2 R114.2 R115.2 R116.2 R118.2 R125.2 R232.2 R235.2 R299.2 R301.2 R307.1 R310.1 R314.2 R316.2 R317.2 R325.1 R326.1 R328.1 R331.1 R363.1 U4.9 U4.13 U4.18 U4.22 U4.26 U11.6 U20.6 U21.6 U22.6 U23.6 U31.6 U32.6 | length 4517.9
  Top Layer w6: R331.1@2000.31,1489.53 R331.1@2004.05,1489.53 ; v1@2030.89,1457.53 v1(2032.37,1456.06) ; v1@2049.37,1493.06 v1(2051.37,1495.06) ; J4.2@2083.67,4053.08 J4.2@2085.84,4055.25
  Top Layer w7.8: R125.2@553,222.59 553,251 v1(554,252)
  Top Layer w8: C109.1@564.2,904.23 590.76,877.66 v1(618,877.66) ; U31.6@572.1,984.03 608.97,984.03 v1(623,970) ; v1(1718.62,1536.53) 1708.54,1536.53 C26.2@1689.22,1517.21 1691.59,1514.84 U23.6@1743.74,1514.84
  Top Layer w9.8: C7.2@1642.37,2653.74 1645.05,2651.06 U20.6@1685.43,2651.06 ; R299.2@2254.68,1619.06 2254.68,1648.45 v1(2257.89,1651.66) ; v1(2265,1745) 2285.32,1745 R307.1@2295.32,1755
  Top Layer w10: v1(2025.37,4029.06) 2051.56,4055.25 J4.2@2081.5,4055.25
  Top Layer w15: v1(467.37,1960.86) 471.27,1964.76 544.67,1964.76 C112.1@550.37,1959.06 ; v1(651.37,1520.06) 677.92,1493.5 R113.2@746.37,1493.5 ; v1(1549,1794.5) 1570.67,1816.17 R3.2@1575,1816.17 ; v1(1611.37,2654.06) 1611.68,2653.74 C7.2@1642.37,2653.74 ; R317.2@2000.31,1457.53 v1@2030.89,1457.53 ; R331.1@2004.05,1493.06 v1@2049.37,1493.06
  Top Layer w20: C112.1@550.37,1959.06 573.84,1959.06 638.97,1893.92 U32.6@638.97,1880.25 ; v1(1831.37,2520.06) R301.2@1861.68,2520.06 ; R310.1@1943.78,2591.69 1951.01,2591.69 v1(1972.37,2613.06) ; v1(2573.37,4393.06) R118.2@2604.68,4393.06
  L3-SIG1 w7.8: v1(618,877.66) 596.27,899.39 596.27,945.8 620.47,970 v1(623,970)
  L3-SIG1 w10: v1(554,252) 395.52,252 302.21,345.31 302.21,692.9 353.31,744 484.34,744 v1(618,877.66)
  L5-PWR/SIG w25: v1(2025.37,4029.06) 2213.54,4029.06 2286.58,4102.1 2286.58,4174.58 2505.06,4393.06 v1(2573.37,4393.06)
  Bottom Layer w9: U4.18@1934.46,2020.25 1967.57,2020.25 v1(1969.37,2022.06)
  Bottom Layer w10: v1(467.37,1960.86) 468.77,1962.26 523.17,1962.26 539.37,1946.06 R363.1@539.37,1925.68 ; R316.2@1595.68,2568.06 1615.57,2548.17 1615.57,2514.26 v1(1615.37,2514.06) ; v1(1745.37,2177.06) 1770.37,2152.06 v1(1773.37,2152.06) 1805.18,2152.06 1820.28,2136.95 U4.9@1820.28,2090.73 ; v1(1783.37,1908.06) 1789.37,1914.06 1810.37,1914.06 1820.28,1923.97 U4.26@1820.28,1969.47 ; U22.6@1852.76,2651.06 1888.78,2651.06 C25.2@1904.09,2666.38 1904.09,2710.78 v1(1920.37,2727.06) ; v1(1897.37,1554.06) 1957.14,1554.06 1964.68,1546.51 C8.2@1964.68,1514.06 1963.9,1514.84 U21.6@1911.06,1514.84 ; U4.22@1899.02,1969.47 1899.02,1928.01 1916.96,1910.07 1940.36,1910.07 1950.43,1900 v1(1955,1900) ; U4.13@1899.02,2090.73 1899.02,2123.71 1930.37,2155.06 v1(1942.37,2155.06) ; R105.2@2114.37,1949.37 2114.37,1921.52 v1(2115.83,1920.06) ; U11.6@2203.71,1652.69 2256.86,1652.69 v1(2257.89,1651.66) 2255.63,1649.4 C6.2@2255.63,1605 ; v1(2627.37,1844.06) 2631.68,1839.74 R114.2@2631.68,1781.06
  Bottom Layer w15: v1(846.37,3725.06) 846.92,3724.5 R59.2@846.92,3616.06 ; R33.1@1301.81,1647.4 v1(1329.75,1647.4) ; v1(1621.37,1446.06) 1624.16,1443.27 R314.2@1650.75,1443.27 ; v1(1624.89,1478.27) R325.1@1650.75,1478.27 ; v1(1969.37,2022.06) 1985.77,2038.46 C17.2@2002.53,2038.46
  Bottom Layer w20: R232.2@556.77,4466.97 611.46,4466.97 619.66,4458.77 v1(619.66,4440.31) ; R326.1@588.32,904.23 604.2,904.23 618,890.43 v1(618,877.66) 648.11,877.66 v1(659.37,866.4) ; R316.2@1595.68,2568.06 R328.1@1595.68,2602.06 ; v1(1942.37,2155.06) 1944.37,2155.06 v1(1968.37,2179.06) 1968.37,2224.61 C10.2@1971.22,2227.46
  other v1: 2411.51,615.31 2410.15,652 2409.37,684.06 2344.37,704.06 2409.37,749.06 1976.37,1878.06 1755.37,1890.06 746.67,3422.56 770.37,3442.06 895,3700 634.57,4467
14PIN_RTCK: J19.9 R44.2 | length 226.2
  Bottom Layer w6: R44.2@2467.37,2731.43 2506.75,2692.06 2608.06,2692.06 J19.9@2657,2741
14PIN_TCK: J19.11 R44.1 U36.1 | length 2817.3
  L6-SIG2 w4.5: v1(759.37,1899.06) 761.82,1901.51 854,1901.51 908.51,1847 1168.53,1847 1210.53,1805 1238.75,1805 1343.75,1910 1417,1910 1437,1930 1517.14,1930 1579.41,1992.27 1579.41,2110.74 1704.74,2236.06 1893.49,2236.06 2125,2467.57 2125,2610 2237.06,2722.06 2325.37,2722.06 2394.37,2791.06 2607.06,2791.06 J19.11@2657,2841
  Bottom Layer w6: U36.1@741.99,1971.53 741.99,1961.43 761.37,1942.06 761.37,1901.06 v1(759.37,1899.06) ; R44.1@2467.37,2778.68 2482.75,2794.06 2610.06,2794.06 J19.11@2657,2841
14PIN_TDI: J19.3 U36.8 | length 2651.9
  L6-SIG2 w4.5: v1(589.84,2020.37) 606.62,2020.37 673.37,1953.62 673.37,1901.52 774.83,1800.06 919.37,1800.06 961.57,1757.86 1200.67,1757.86 1210.07,1748.46 1357.35,1748.46 1430,1821.11 1430,1835 1448.9,1853.9 1788.11,1853.9 1915.64,1981.42 1979.42,1981.42 2375,2377 2375,2417.25 2446.75,2489 2609,2489 J19.3@2657,2441
  Bottom Layer w6: v1(589.84,2020.37) 594.33,2024.86 624.37,2024.86 624.55,2024.68 U36.8@671.13,2024.68
14PIN_TDO: J19.7 U36.11 | length 2672.1
  L6-SIG2 w4.5: v1(735.37,2003.06) 719.37,1987.06 687.17,1954.86 687.17,1904.69 778.8,1813.06 924.8,1813.06 968,1769.86 1212.4,1769.86 1223.26,1759 1279.03,1759 1302.78,1782.76 1302.78,1845.2 1354.24,1896.66 1425.09,1896.66 1443.44,1915 1518.31,1915 1553.31,1950 1611.83,1950 1664,2002.17 1664,2153 1735.06,2224.06 2120.06,2224.06 2264,2368 2293.94,2368 2485,2559.06 2575.06,2559.06 J19.7@2657,2641
  Bottom Layer w6: U36.11@726.24,2032.55 726.24,2012.18 v1(735.37,2003.06)
14PIN_TMS: J19.1 U36.4 | length 2795
  L6-SIG2 w4.5: v1(514.37,1993.06) 560.37,1993.06 765.37,1788.06 913.37,1788.06 956.37,1745.06 1121.37,1745.06 1154.57,1711.86 1210.53,1711.86 1231.4,1732.73 1374.99,1732.73 1445.36,1803.11 1502.28,1803.11 1539.17,1840 1868.63,1840 1912.83,1884.19 1912.83,1899.02 2383.81,2370 2425,2370 2450,2395 2603,2395 J19.1@2657,2341
  Bottom Layer w6: v1(514.37,1993.06) 556.75,1993.06 607.95,1941.86 682.17,1941.86 694.75,1954.43 U36.4@694.75,1969.56
14PIN_TRST: J19.2
40PIN_BSS_LOGGER: R88.1 U33.12 | length 1594.3
  Top Layer w6: U33.12@1432.97,2121.74 1432.97,2160.4 1427.58,2165.79 1427.58,2188.92 1437.71,2199.06 1452.51,2199.06 1493.25,2239.79 1493.25,2278.14 1532.91,2317.8 1567.22,2317.8 1601.75,2352.33 1601.75,2415.66 1634.32,2448.23 1795.86,2448.23 1835.98,2488.35 1989.53,2488.35 2129.37,2628.19 2129.37,2969.06 2109.37,2989.06 v1(2029.37,2989.06)
  Bottom Layer w6: R88.1@1909.37,2959.06 1929.37,2959.06 1959.37,2989.06 v1(2029.37,2989.06)
40PIN_CS1: R64.1 R72.2 U24.12 | length 2931
  Top Layer w6: R72.2@2243.06,3443 2284.31,3401.75 2284.31,3401 R64.1@2246.68,3401
  L3-SIG1 w4: v1(721.54,2417.39) 721.54,2446.01 733.46,2457.93 775,2457.93 813.37,2419.56 888.31,2419.56 903.28,2434.53 1015.76,2434.53 1045.77,2404.52 1195.52,2404.52 1210.56,2419.56 1294.88,2419.56 1313.67,2438.36 1313.67,2557.2 1378.72,2622.26 1472.51,2622.26 1488.64,2606.13 1751.05,2606.13 1781.08,2576.1 1987.02,2576.1 2050.11,2639.19 2050.11,2912.07 1995.2,2966.98 1995.2,3413.45 2013.61,3431.86 2073.64,3431.86 2113.19,3471.41 2214.02,3471.41 v1(2284.37,3401.06)
  Bottom Layer w6: U24.12@658.25,2358.44 658.25,2367.94 674.37,2384.06 688.21,2384.06 v1(721.54,2417.39)
40PIN_DSS_LOGGER: J6.4 R362.2 | length 1249.9
  Top Layer w6: v1(2167.37,3542.06) v1@2168.31,3543
  L8-SIG3 w4: v1(1642.37,4373.06) 1686.37,4329.06 1804.37,4329.06 1844.37,4289.06 1844.37,3928.06 2167.37,3605.06 v1(2167.37,3542.06)
  Bottom Layer w6: v1(1642.37,4373.06) 1674.43,4341 R362.2@1697.01,4341
  Bottom Layer w10: v1(2167.37,3542.06) 2168.31,3543 J6.4@2230.07,3543
40PIN_GPI0_0: R79.1 U26.1 | length 1881.4
  Top Layer w6: v1(1350.37,2380.06) 1369.97,2380.06 1372.17,2377.86 1418.17,2377.86 1428.62,2388.31 U26.1@1428.62,2400.02
  L6-SIG2 w4.5: v1(137.37,2940.06) 239.37,2838.06 340.37,2838.06 356.37,2822.06 356.37,2775.06 292.72,2711.41 292.72,2635.28 345,2583 480,2583 530.4,2633.4 621.09,2633.4 655,2599.49 655,2529 710.37,2473.63 883.26,2473.63 918,2438.89 1087.01,2438.89 1112.76,2464.64 1265.79,2464.64 v1(1350.37,2380.06)
  Bottom Layer w6: v1(137.37,2940.06) 138.37,2941.06 R79.1@174.39,2941.06
40PIN_GPI0_1: R76.2 U26.4 | length 1838.7
  Top Layer w6: U26.4@1475.87,2398.06 1475.87,2347.56 v1(1484.37,2339.06) ; R76.2@2237.36,3359.06 v1(2294.37,3359.06)
  L3-SIG1 w4: v1(1484.37,2339.06) 1497.43,2326 1621,2326 1642.42,2304.58 1756.63,2304.58 1778.91,2326.86 1838.17,2326.86 2338.1,2826.79 2338.1,3036.9 2221,3154 2221,3326.16 2253.9,3359.06 v1(2294.37,3359.06)
40PIN_GPI0_2: R92.2 U26.8 | length 1260.3
  Top Layer w6: U26.8@1499.49,2453.17 1499.49,2452.86 1524.37,2452.86 1555.17,2422.06 v1(1559.37,2422.06) ; R92.2@2243.06,2843 2291.31,2843 v1(2293.37,2845.06)
  L6-SIG2 w4.5: v1(1559.37,2422.06) 1953.28,2422.06 2061.57,2530.34 2061.57,2671.76 2040.17,2693.16 2040.17,2840.42 2063,2863.26 2275.17,2863.26 v1(2293.37,2845.06)
40PIN_HOSTINTR1: R91.2 R95.2 U25.16 | length 1263.7
  Top Layer w6: v1(1411.37,2535.06) 1421.07,2544.76 U25.16@1464.81,2544.76 ; R91.2@2243.06,2943 2271.43,2943 v1(2297.37,2917.06) 2279.37,2899.06 R95.2@2250.06,2899.06
  L3-SIG1 w4: v1(1411.37,2535.06) 1542.2,2535.06 1560.48,2553.34 2005.65,2553.34 2129.54,2677.23 2129.54,2749.23 v1(2297.37,2917.06)
40PIN_MCU_SOP0: R94.1 U27.1 | length 2085.9
  Top Layer w6: R94.1@2020.62,2743 2072.31,2743 v1(2072.37,2743.06)
  L6-SIG2 w4.5: v1(800.37,2119.06) 817.8,2119.06 834,2135.26 871.17,2135.26 898.56,2107.87 898.56,2061.44 982.3,1977.7 1056.01,1977.7 1087.31,2009 1162.14,2009 1207,2053.86 1318.11,2053.86 1334.11,2037.86 1358.74,2037.86 1378.88,2058 1473.84,2058 1489.17,2073.33 1489.17,2173.52 1509.57,2193.92 1509.57,2254.2 1561.22,2305.85 1872.6,2305.85 2097.37,2530.62 2097.37,2718.06 v1(2072.37,2743.06)
  Bottom Layer w6: U27.1@745.99,2152.53 745.99,2134.43 761.37,2119.06 v1(800.37,2119.06)
40PIN_MCU_SOP1: R93.1 U27.4 | length 2289.2
  Top Layer w6: R93.1@2020.62,2843 2071.31,2843 v1(2071.37,2843.06)
  L6-SIG2 w4.5: v1(684.37,2099.06) 754.57,2169.26 878.53,2169.26 917.07,2130.72 917.07,2060.05 987.13,1990 1042.33,1990 1138.22,2085.89 1214.85,2085.89 1234.88,2065.86 1329.6,2065.86 1342.6,2078.86 1417.17,2078.86 1475,2136.69 1475,2187 1464.62,2197.38 1464.62,2217.64 1486.07,2239.09 1486.07,2259.8 1544.64,2318.37 1866.57,2318.37 2073.57,2525.37 2073.57,2713.29 2052.17,2734.69 2052.17,2823.86 v1(2071.37,2843.06)
  Bottom Layer w6: v1(684.37,2099.06) 698.75,2113.43 U27.4@698.75,2150.56
40PIN_MCU_SOP2: R90.1 U27.8 | length 2459.3
  Top Layer w6: v1(1944.37,2944.06) 1945.43,2943 R90.1@1994.64,2943
  L6-SIG2 w4.5: v1(634,2191.3) 646.96,2204.26 753.17,2204.26 776.17,2181.26 961.16,2181.26 1008.17,2134.25 1008.17,2051.86 1016.01,2044.01 1016.01,2019.87 1025.88,2010 1046.44,2010 1132.83,2096.39 1226.3,2096.39 1244.83,2077.86 1324.63,2077.86 1337.63,2090.86 1391.57,2090.86 1424.51,2123.8 1424.51,2277.73 1459.71,2312.93 1459.71,2350.96 1552.8,2444.06 1958.31,2444.06 2049.57,2535.31 2049.57,2655.83 2028.17,2677.23 2028.17,2860.26 v1(1944.37,2944.06)
  Bottom Layer w6: v1(634,2191.3) 648.38,2205.68 U27.8@675.13,2205.68
40PIN_MCUCLKOUT: J6.5 R360.2 | length 1363.4
  L8-SIG3 w4: v1(1664.63,4406) 1646.75,4406 1622.17,4381.42 1622.17,4350.26 1660.58,4311.85 1804.61,4311.85 1831,4285.46 1831,3919.63 1985.37,3765.26 1985.37,3488.06 v1(1941.37,3444.06)
  Bottom Layer w6: v1(1664.63,4406) 1671.88,4398.75 R360.2@1715.25,4398.75 ; v1(1941.37,3444.06) 1942.43,3443 J6.5@2007.63,3443
40PIN_MISO1: R89.2 R393.2 U24.9 | length 2919.3
  Top Layer w6: R393.2@2245,3077.01 2245,3032.99 R89.2@2247.99,3030 2292.43,3030 v1(2294.37,3028.06)
  L3-SIG1 w4: v1@598.29,2415.7 v1(598.29,2409.43) 635.69,2372.03 711.65,2372.03 740.98,2401.36 899.48,2401.36 950.03,2350.81 1075.78,2350.81 1115.59,2390.62 1235.44,2390.62 1252.38,2407.56 1299.85,2407.56 1362.34,2470.06 1362.34,2523.17 1399.09,2559.92 1458.86,2559.92 1473.72,2545.06 1535.92,2545.06 1555.48,2564.62 1995.21,2564.62 2109.82,2679.23 2109.82,2955.51 2020.55,3044.78 2020.55,3193.16 2059.95,3232.56 2176.69,3232.56 2199.47,3209.78 2199.47,3045.96 2217.37,3028.06 v1(2294.37,3028.06)
  Bottom Layer w6: v1(598.29,2409.43) 611.01,2396.71 U24.9@611.01,2358.44
40PIN_MOSI1: R85.2 R394.2 U24.3 | length 2897.8
  Top Layer w6: v1(2168.37,3145.06) 2169.37,3144.06 R85.2@2215.37,3144.06 2215.37,3114.37 R394.2@2206,3105
  L3-SIG1 w4: v1(616.4,2329.43) 649,2362.03 715.79,2362.03 745.02,2391.26 887.47,2391.26 939.29,2339.44 1211.63,2339.44 1221.45,2349.26 1370.57,2349.26 1410.65,2389.34 1472.09,2389.34 1493.57,2367.86 1542.71,2367.86 1548.85,2374 1566.32,2374 1594.72,2345.6 1617.4,2345.6 1648.42,2314.58 1750.68,2314.58 1776.83,2340.73 1820.53,2340.73 2323.3,2843.5 2323.3,2948.87 2298.84,2973.33 2250,2973.33 2241.23,2982.1 2241.23,3004 2235.23,3010 2213.33,3010 2205.37,3002.04 2205.37,2981.22 2197.47,2973.32 2116.02,2973.32 2093.37,2995.97 2093.37,3193.41 2106.68,3206.72 2150.55,3206.72 2168.37,3188.9 v1(2168.37,3145.06)
  Bottom Layer w6: v1(616.4,2329.43) 626.76,2319.07 U24.3@626.76,2295.45
40PIN_MSS_LOGGER: R81.1 U33.9 | length 2302.8
  Top Layer w6: U33.9@1480.21,2121.74 1480.21,2161.44 1509.57,2190.79 1509.57,2277.49 1537.88,2305.8 1572.19,2305.8 1613.75,2347.36 1613.75,2409.25 1640.09,2435.59 1804.08,2435.59 1841.36,2472.87 1997.11,2472.87 2267.39,2743.15 2404,2743.15 2456.9,2796.05 2456.9,3085.85 2413.69,3129.06 2375.94,3129.06 2300,3205 v1(2300,3230) ; R81.1@2020.62,3243 2097.62,3320 2290,3320 v1(2300,3330)
  L3-SIG1 w4: v1(2300,3230) v1(2300,3330)
40PIN_NERR_OUT: R67.1 U26.11 | length 2226.2
  Top Layer w6: v1(1434.37,2431.06) 1444.37,2441.06 U26.11@1444.37,2461.05 ; R67.1@2157.36,3644.06 2191.37,3644.06 v1(2228.37,3681.06)
  L6-SIG2 w4.5: v1(1434.37,2431.06) 1452.17,2448.86 1491.34,2448.86 1519.37,2476.89 1519.37,2495.06 ; 1520.17,2495.06 1520.17,2495.86 1577.57,2553.26 1639.37,2553.26 1669.17,2523.46 1669.17,2494.69 1707.8,2456.06 1953.34,2456.06 2037.57,2540.29 2037.57,2650.86 2000.37,2688.06 2000.37,2852.06 1924.17,2928.26 1924.17,2960.86 1948.37,2985.06 1986.94,2985.06 2118.37,3116.49 2118.37,3140.06 2244.37,3266.06 2244.37,3665.06 v1(2228.37,3681.06)
40PIN_NERRIN: R60.1 R70.1 U27.11 | length 2825.2
  Top Layer w6: v1(1942.37,3536.06) 1949.31,3543 R70.1@1994.64,3543 1994.64,3504.32 R60.1@1990.32,3500
  L5-PWR/SIG w4.5: v1(976,2241.97) 1075.64,2341.61 1385.58,2341.61 1417.02,2310.17 1556.82,2310.17 1573.84,2327.19 1573.84,2363.85 1551.57,2386.12 1551.57,2398.42 1520.17,2429.82 1520.17,2506.79 1475.06,2551.9 1475.06,2602.03 1499.57,2626.54 1499.57,2673.26 1516.37,2690.06 1531.37,2690.06 1548.17,2706.86 1548.17,2725.97 1556.57,2734.37 1556.57,2771.94 1544.13,2784.38 1544.13,2822.39 1515.8,2850.72 ; 1515.8,2850.77 1407.33,2959.24 1407.33,3128.63 1391.17,3144.79 1391.17,3186.35 1525.97,3321.15 1525.97,3409.63 1605.14,3488.8 1654.37,3488.8 1701.62,3536.06 v1(1942.37,3536.06)
  Bottom Layer w6: U27.11@730.24,2213.55 730.24,2233.54 763.36,2266.66 810.34,2266.66 856,2221 955.03,2221 v1(976,2241.97)
40PIN_NRST: R78.2 U25.3 | length 1355.7
  Top Layer w6: U25.3@1519.93,2536.88 1519.93,2506.07 1532,2494 1559,2494 1586.14,2466.86 1752.35,2466.86 1802,2516.51 1802,2649.66 1821.34,2669 1870,2669 1897.25,2696.25 1897.25,2765.97 1915.39,2784.11 1915.39,2975.11 1965.94,3025.66 2100.88,3025.66 2130,3054.78 2130,3145 2217.08,3232.08 R78.2@2217.08,3243
40PIN_PGOOD: J5.14 R75.2 | length 1400
  L6-SIG2 w4.5: v1(139.37,3255.06) 160.57,3233.86 160.57,2997.92 214.43,2944.06 296.94,2944.06 437,2804 520,2804 657,2941 697.47,2941 729.37,2972.9 729.37,3011.06 v1(756.37,3038.06)
  Bottom Layer w6: J5.14@530.07,3043 614,3043 676,3105 740,3105 756.37,3088.63 v1(756.37,3038.06)
  Bottom Layer w10: R75.2@136.38,3227 136.38,3252.06 v1(139.37,3255.06)
40PIN_PMIC_CLKOUT_SOP2: J5.20 R349.2 | length 2720.3
  L8-SIG3 w4: v1(415.37,2650.06) 416.57,2648.86 489.31,2648.86 606.37,2765.91 606.37,3257.14 622.68,3273.45 622.68,3299.06 655.26,3331.64 655.26,3562.51 1516.37,4423.63 1516.37,4440.95 1555.43,4480 1598.88,4480 1639.37,4520.49 v1(1639.37,4549.06)
  Bottom Layer w6: v1@415.37,2660.06 415.37,2690.06 430.75,2705.43 471.84,2705.43 509.41,2743 J5.20@530.07,2743
  Bottom Layer w10: v1(1639.37,4549.06) 1642.56,4552.24 R349.2@1715.25,4552.24
40PIN_PMIC_EN: J5.16 R353.2 | length 1974.5
  Bottom Layer w6: J5.16@530.07,2943 504,2943 484,2963 462,2963 439.37,2985.63 439.37,3766.03 627.64,3954.3 627.64,4356.64 689,4418 689,4590 708,4609 796.98,4609 813.62,4592.36 R353.2@813.62,4573.35
40PIN_RS232RX: J5.7 R56.1 U25.12 | length 2365.3
  Top Layer w6: v1(1457.37,2686.06) 1457.37,2651.06 1488.43,2619.99 U25.12@1488.43,2599.87
  L6-SIG2 w4.5: v1(193.37,3311.06) 178.37,3296.06 178.37,3005.06 225.17,2958.26 306.74,2958.26 419.74,2845.26 544.29,2845.26 658,2958.97 658,3050.29 704.71,3097 750.64,3097 802.64,3045 802.64,2844.22 976.86,2670 1091.26,2670 1105,2656.26 1284.1,2656.26 1314,2686.16 1324.27,2686.16 1324.56,2686.44 1340.17,2686.44 1340.45,2686.16 1457.27,2686.16 v1(1457.37,2686.06)
  Bottom Layer w6: v1(193.37,3311.06) 193.37,3329.37 R56.1@206,3342 207,3343 J5.7@307.63,3343
40PIN_RS232TX: J5.5 R55.1 U25.9 | length 2356
  Top Layer w6: v1(1494.57,2712.86) 1541.17,2666.26 1541.17,2649.06 1535.68,2643.56 U25.9@1535.68,2599.87
  L6-SIG2 w4.5: v1(206.68,3477.37) 206.5,3477.56 206.5,3333.56 213.57,3326.49 213.57,3249.86 254.57,3208.86 254.57,3138.26 208.74,3092.42 208.74,3049.3 225.58,3032.46 356.54,3032.46 426,2963 487,2963 653,3129 765.66,3129 843.29,3051.36 861.74,3051.36 931.37,2981.73 931.37,2950.92 978.03,2904.26 1088.74,2904.26 1148.57,2844.43 1148.57,2808.86 1182.78,2774.65 1338.53,2774.65 1359.14,2795.26 1387.17,2795.26 1469.57,2712.86 v1(1494.57,2712.86)
  Bottom Layer w6: v1(206.68,3477.37) R55.1@206.68,3443 J5.5@307.63,3443
40PIN_SCL: R57.1 R82.1 U33.16 | length 2065.6
  Top Layer w6: v1(1387.37,2031.06) 1409.35,2053.03 U33.16@1409.35,2066.62
  L6-SIG2 w4.5: v1(148.37,2845.06) 170.37,2823.06 170.37,2625.29 472.17,2323.49 472.17,2242.23 497.91,2216.49 529.45,2216.49 556.97,2188.96 556.97,2165.46 583.37,2139.06 615.8,2139.06 676,2078.86 694.6,2078.86 731,2115.26 773.74,2115.26 794.14,2094.86 820.24,2094.86 894.75,2020.35 894.75,1988.44 976.33,1906.86 1092.86,1906.86 1227.86,2041.86 1313.14,2041.86 1329.14,2025.86 1382.17,2025.86 v1(1387.37,2031.06)
  Bottom Layer w6: R57.1@182.37,2808.06 158.37,2808.06 148.37,2818.06 v1(148.37,2845.06) 149.37,2844.06 R82.1@185.38,2844.06
40PIN_SDA: R58.1 R86.1 U33.3 | length 2048.7
  Top Layer w6: U33.3@1464.46,2058.75 1464.46,2029.91 v1(1469.37,2025)
  L6-SIG2 w4.5: v1(135.37,2743.06) 135.37,2633.06 456.37,2312.06 456.37,2241.06 492.94,2204.49 524.47,2204.49 544.97,2183.99 544.97,2127.89 580.38,2092.48 647.53,2092.48 688.15,2051.86 749.08,2051.86 755.88,2045.06 825.88,2045.06 877.88,1993.05 877.88,1981.93 964.95,1894.86 1099.8,1894.86 1162.94,1958 1222.29,1958 1255.64,1991.35 1306.19,1991.35 1320.34,2005.5 1390.48,2005.5 1409.98,2025 v1(1469.37,2025)
  Bottom Layer w6: v1(135.37,2743.06) 135.37,2713.06 146.37,2702.06 R58.1@180.68,2702.06
  Bottom Layer w10: v1(135.37,2743.06) 136.37,2742.06 R86.1@183.38,2742.06
40PIN_SPI_CLK1: R77.1 U24.16 | length 2957.9
  L8-SIG3 w4: v1(131.37,3045.06) 91.37,3045.06 79.37,3033.06 79.37,2991.98 86.62,2984.73 126.28,2984.73 133.53,2977.48 133.53,2962.98 126.28,2955.73 86.62,2955.73 79.37,2948.48 79.37,2933.98 86.62,2926.73 123.55,2926.73 130.8,2919.48 130.8,2904.98 123.55,2897.73 86.62,2897.73 79.37,2890.48 79.37,2875.98 86.62,2868.73 122.02,2868.73 129.27,2861.48 129.27,2846.98 122.02,2839.73 86.62,2839.73 79.37,2832.48 79.37,2817.98 86.62,2810.73 175.48,2810.73 182.73,2803.48 182.73,2788.98 175.48,2781.73 86.62,2781.73 79.37,2774.48 79.37,2739.81 86.62,2732.56 118.72,2732.56 125.97,2725.31 125.97,2710.81 118.72,2703.56 86.62,2703.56 79.37,2696.31 79.37,2681.81 86.62,2674.56 173.46,2674.56 180.71,2667.31 180.71,2652.81 173.46,2645.56 86.62,2645.56 79.37,2638.31 79.37,2623.81 86.62,2616.56 173.46,2616.56 180.71,2609.31 180.71,2594.81 173.46,2587.56 86.62,2587.56 79.37,2580.31 79.37,2565.81 86.62,2558.56 173.46,2558.56 180.71,2551.31 180.71,2536.81 173.46,2529.56 86.62,2529.56 79.37,2522.31 79.37,2486.06 99,2466.43 109.25,2466.43 149.15,2506.33 159.4,2506.33 169.65,2496.07 169.65,2485.82 129.76,2445.92 129.76,2435.67 154.5,2410.93 164.75,2410.93 197.98,2444.16 208.24,2444.16 218.49,2433.91 218.49,2423.66 185.26,2390.42 185.26,2380.17 208.78,2356.65 208.78,2356.07 308.81,2256.03 308.81,2185.61 323.37,2171.06 381.37,2171.06 394.17,2183.86 394.17,2214.78 399,2219.61 415.11,2219.61 424.01,2228.51 481.72,2228.51 491.37,2218.86 556.63,2218.86 581.03,2243.26 661.6,2243.26 676,2228.86 717.74,2228.86 740.57,2251.69 740.57,2278.64 v1(730.26,2288.95)
  Bottom Layer w6: U24.16@681.87,2303.32 715.88,2303.32 v1(730.26,2288.95)
  Bottom Layer w10: v1(131.37,3045.06) 132.37,3044.06 R77.1@170.37,3044.06
40PIN_SYNC_IN: J5.9 R348.2 | length 2695.9
  L6-SIG2 w4.5: v1(235.37,3277.06) 278.31,3320 774.31,3320 863.17,3408.86 993.71,3408.86 1012.8,3427.95 1012.8,3451.05 1061.3,3499.56 1233.61,3499.56 1369.85,3635.8 1911.27,3635.8 1941.37,3665.9 1941.37,3905.09 1928.43,3918.03 1928.43,4028.5 1994.37,4094.44 1994.37,4104.98 2007.65,4118.26 2026.21,4118.26 2046.37,4138.42 2046.37,4147.8 v1(2149.6,4251.03)
  Bottom Layer w10: v1(235.37,3277.06) 247.94,3277.06 282,3243 J5.9@307.63,3243 ; R348.2@2113.63,4251.03 v1(2149.6,4251.03)
40PIN_SYNC_OUT_SOP1: J5.18 R351.2 | length 4938.2
  Top Layer w6: v1(757.37,2878.49) 777.57,2858.29 777.57,2704.47 702.1,2629 662,2629 643,2648 594.5,2648 548.76,2602.27 548.76,2567.61 524.66,2543.5 474.75,2543.5 411.26,2607 322.86,2607 223.58,2706.28 223.58,3034.45 213.75,3044.29 213.75,3121.58 214.17,3122 214.17,3296.26 226.88,3308.97 226.88,3512.11 146,3593 146,3674 187,3715 671.37,3715 838.23,3881.86 1737.6,3881.86 1748.8,3893.06 2159.06,3893.06 2307.55,4041.55 2307.55,4053 2360.55,4106 2447,4106 2532.37,4191.37 2532.37,4321.44 2504.94,4348.87 R351.2@2502.25,4348.87
  Bottom Layer w6: J5.18@530.07,2843 721.88,2843 v1(757.37,2878.49)
40PIN_WARMRST: J6.11 R61.1 R358.2 | length 2526.7
  Top Layer w6: v1(1949.07,3171.36) 1990.32,3130.12 R61.1@1990.32,3095
  L8-SIG3 w4: v1(1662.63,4606) 1696,4606 1835,4745 1941.06,4745 2105,4581.06 2146.83,4581.06 2168.83,4559.06 2168.83,4483.12 2089.37,4403.66 2089.37,4258.52 1993.17,4162.32 1993.17,3798.26 2187.57,3603.86 2187.57,3518.26 1986.37,3317.06 1986.37,3208.67 v1(1949.07,3171.36)
  Bottom Layer w6: v1(1662.63,4606) 1668.38,4611.75 R358.2@1742.63,4611.75 ; v1(1949.07,3171.36) 1977.43,3143 J6.11@2007.63,3143
60PIN_CS1: J10.7 U24.11 | length 2886.8
  Top Layer w6: v1(327.43,3184.67) 329.72,3186.96 J10.7@403.5,3186.96
  L8-SIG3 w4: v1(327.43,3184.67) 327.43,3301.85 339,3313.43 370.57,3313.43 380.03,3303.97 380.03,2875.03 356.37,2851.37 356.37,2785.37 330.86,2759.86 291.42,2759.86 281.37,2749.81 281.37,2734.06 272.37,2725.06 257.37,2725.06 247.37,2735.06 247.37,2763 272.57,2788.2 272.57,2810.43 262,2821 231,2821 218.37,2808.37 218.37,2696.06 230.57,2683.86 255.57,2683.86 265.37,2674.06 265.37,2650.06 272.37,2643.06 296.94,2643.06 310,2630 310,2615 305.06,2610.06 270.37,2610.06 263.37,2603.06 263.37,2588.06 270.37,2581.06 319.37,2581.06 328.37,2572.06 328.37,2552.06 318.37,2542.06 219.37,2542.06 213.37,2536.06 213.37,2515.06 228.37,2500.06 253.17,2500.06 262.3,2490.93 272.55,2490.93 297.65,2516.03 307.9,2516.03 318.16,2505.78 318.16,2495.53 287.93,2465.3 276.52,2453.88 276.52,2443.63 286.77,2433.38 297.02,2433.38 308.44,2444.79 338.66,2475.02 348.92,2475.02 359.17,2464.77 359.17,2454.51 334.07,2429.41 334.07,2419.16 344.32,2408.91 354.57,2408.9 379.68,2434.01 389.93,2434.01 400.18,2423.75 400.18,2413.5 375.08,2388.4 375.08,2378.15 384.27,2368.96 384.27,2356.96 359,2331.69 359,2320 369.13,2309.87 379.18,2309.87 397.37,2328.06 410.37,2328.06 415.37,2323.06 415.37,2288.63 441.95,2262.06 472.37,2262.06 480.17,2269.86 480.17,2297.01 491.42,2308.26 507.32,2308.26 516.72,2298.86 546.57,2298.86 559.2,2286.23 559.2,2273 573.14,2259.06 663.37,2259.06 673.37,2269.06 673.37,2344.63 660,2358 634,2358 621,2371 621,2384 628,2391 628,2391.23 v1(648.02,2391.23)
  Bottom Layer w6: U24.11@642.5,2358.44 642.5,2385.72 v1(648.02,2391.23)
60PIN_HOSTINTR1: J10.10 U25.1 | length 1511.9
  Top Layer w6: J10.10@629.09,3167.28 688.98,3167.28 v1(695,3173.3) ; v1(1429.37,2510) 1437.43,2518.06 1482.37,2518.06 1488.43,2524.12 U25.1@1488.43,2538.85
  Bottom Layer w6: v1(695,3173.3) 695,3146.92 710.92,3131 759,3131 776.57,3113.43 776.57,2896.12 783.97,2888.73 783.97,2785 760,2761.03 760,2624.61 787.39,2597.23 856.1,2597.23 910.07,2543.26 975.22,2543.26 1036.67,2481.81 1401.18,2481.81 v1(1429.37,2510)
60PIN_JTAG_TCK: J4.15 R240.1 U36.2 | length 4016.8
  Top Layer w6: v1(1652.37,4174.06) 1672.51,4194.2 1838.5,4194.2 J4.15@1838.5,4193.15 J4.15@1841.57,4190.08
  L8-SIG3 w4: v1(738.37,1926.06) 839.91,1926.06 1048.82,2134.97 1048.82,2668.18 1033,2684 1033,2739.06 1006.24,2765.82 919.22,2765.82 815,2870.04 815,3072.37 783.17,3104.2 783.17,3324.47 947.17,3488.47 947.17,3560.42 959,3572.26 1087.71,3572.26 1152.11,3507.86 1450.29,3507.86 1486.63,3544.2 1603.96,3544.2 1723.57,3663.81 1723.57,3742.97 1658,3808.54 1658,4046 1683.57,4071.57 1683.57,4149.86 1659.37,4174.06 v1(1652.37,4174.06)
  Bottom Layer w6: U36.2@726.24,1969.56 726.24,1938.18 v1(738.37,1926.06) ; v1(1652.37,4174.06) 1664.94,4186.62 R240.1@1926.63,4186.62
60PIN_JTAG_TDI: J4.11 R238.1 U36.7 | length 4793.5
  Top Layer w6: v1(1651.37,4103.06) 1685.77,4137.46 ; 1685.97,4137.25 1710.17,4161.45 1781.92,4161.45 1789.62,4153.75 J4.11@1838.5,4153.75
  L8-SIG3 w4: v1(429.62,1275.53) 455.62,1301.53 455.62,1441.95 348.57,1549 348.57,1981.43 368.4,2001.26 486.57,2001.26 499.64,2014.33 544.67,2014.33 568.94,1990.06 v1(602.37,1990.06) 661.37,1990.06 669.12,1982.31 808.16,1982.31 900,2074.15 900,2170.06 929.26,2199.32 929.26,2539.19 876.7,2591.75 876.7,2655.56 794,2738.27 794,3051 759.17,3085.83 759.17,3334.41 912.37,3487.61 912.37,3585.62 955,3628.26 971.74,3628.26 988.74,3611.26 1130.71,3611.26 1210.11,3531.86 1428.51,3531.86 1464.86,3568.2 1594.02,3568.2 1699.57,3673.75 1699.57,3733.03 1585.37,3847.23 1585.37,4031.06 1651.37,4097.06 v1(1651.37,4103.06)
  Bottom Layer w6: v1(602.37,1990.06) 621.24,2008.93 U36.7@671.13,2008.93
  Bottom Layer w10: R238.1@386.62,1316.91 428,1275.53 v1(429.62,1275.53)
60PIN_JTAG_TDO_SOP0: J4.17 R141.1 R239.1 U36.10 | length 5928.9
  Top Layer w6: R141.1@356.13,853.64 v1(356.13,877.66) ; v1(1589.66,4174.06) 1628.46,4212.85 J4.17@1838.5,4212.85
  L8-SIG3 w4: v1(356.13,877.66) 356.13,949 319,986.13 319,1203 337.82,1221.82 337.82,1985.82 363.2,2011.2 ; 363.47,2011.26 473.14,2011.26 496.94,2035.06 556.34,2035.06 581.88,2060.6 v1(609.3,2060.6) 609.3,2047.7 633.74,2023.26 772.97,2023.26 792.37,2003.86 812.74,2003.86 883.57,2074.69 883.57,2172.46 917.04,2205.93 917.04,2529.03 851.03,2595.04 851.03,2658.13 783.97,2725.19 783.97,3045.4 748,3081.37 748,3340.21 898.37,3490.58 898.37,3588.59 950.03,3640.26 976.71,3640.26 993.71,3623.26 1135.68,3623.26 1215.08,3543.86 1423.54,3543.86 1459.89,3580.2 1589.05,3580.2 1687.57,3678.72 1687.57,3728.06 1573.37,3842.26 1573.37,4157.76 v1(1589.66,4174.06)
  Bottom Layer w6: R239.1@119.38,1286 76.6,1286 61.42,1270.82 61.42,1190.88 218.9,1033.4 218.9,946 287.24,877.66 v1(356.13,877.66) ; v1(609.3,2060.6) 625.6,2076.9 682.96,2076.9 710.5,2049.36 U36.10@710.5,2032.55
60PIN_JTAG_TMS: J4.13 R237.1 U36.5 | length 5202.5
  Top Layer w6: v1(1651.37,4139.06) 1685.76,4173.45 J4.13@1838.5,4173.45
  L8-SIG3 w4: v1(344.17,1178.06) 411.37,1178.06 468,1234.69 468,1452 359.17,1560.83 359.17,1977.89 371,1989.72 402.34,1989.72 411,1981.06 491.37,1981.06 510.37,1962.06 v1(627.37,1962.06) 754.48,1962.06 776.48,1940.06 836.94,1940.06 910,2013.12 910,2141.64 1020.33,2251.97 1020.33,2507.05 896.18,2631.2 896.18,2723.9 805,2815.08 805,3065.4 771.17,3099.23 771.17,3329.44 931.37,3489.64 931.37,3561.59 957.63,3587.86 1095.17,3587.86 1105.57,3598.26 1126.74,3598.26 1205.14,3519.86 1434.24,3519.86 1470.59,3556.2 1598.99,3556.2 1711.57,3668.78 1711.57,3738 1597.37,3852.2 1597.37,4014.49 1671.57,4088.69 1671.57,4118.86 v1(1651.37,4139.06)
  Bottom Layer w6: v1(627.37,1962.06) 642.75,1977.43 U36.5@671.13,1977.43
  Bottom Layer w10: R237.1@168.25,1233.53 223.72,1178.06 v1(344.17,1178.06)
60PIN_MISO1: J10.12 U24.8 | length 2879.4
  Top Layer w6: v1(595.37,3288.06) 567,3259.69 567,3156 575.41,3147.59 J10.12@629.09,3147.59
  L8-SIG3 w4: v1(559.37,2374.06) 559.37,2425.59 575.83,2442.05 575.83,2462.06 607.99,2494.22 635.22,2494.22 643,2502 643,2518 637,2524 592,2524 576,2540 559,2540 548,2529 548,2502 539.15,2493.15 515.31,2493.15 504.06,2481.9 504.06,2346.75 495.37,2338.06 442.31,2338.06 432.37,2348 432.37,2358.06 438.37,2364.06 466.37,2364.06 474.37,2372.06 474.37,2381.06 467.37,2388.06 437.37,2388.06 432.37,2393.06 432.37,2407.06 438.37,2413.06 453.46,2413.06 458.37,2417.97 458.37,2432.06 452.37,2438.06 435.37,2438.06 426.5,2446.92 426.5,2461.56 434,2469.06 475.37,2469.06 481.37,2475.06 481.37,2498.06 477.5,2501.93 371.5,2501.93 366.37,2507.06 366.37,2529.31 373.62,2536.56 490.56,2536.56 496,2542 496,2559.1 489.54,2565.56 373.62,2565.56 366.37,2572.81 366.37,2587.31 373.62,2594.56 434.92,2594.56 442.17,2601.81 442.17,2616.31 434.92,2623.56 373.62,2623.56 366.37,2630.81 366.37,2665 376.37,2675 425,2675 434,2684 434,2695 424,2705 378,2705 366.37,2716.63 366.37,2762.37 386.06,2782.06 410.96,2782.06 425.99,2767.03 425.99,2730.5 442.1,2714.39 515.56,2714.39 595.37,2794.21 595.37,2847 587.37,2855 572,2855 564,2863 564,2873 572,2881 585,2881 595.37,2891.37 v1(595.37,3288.06)
  Bottom Layer w6: v1(559.37,2374.06) 575.37,2374.06 587.39,2362.04 U24.8@587.39,2350.57