# Altium PCB PROC074B-PCB_ASCII.PcbDoc (part 9 of 9)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 2755.91 x 5300 mil, 10 copper layers (Top Layer, L2-GND, L3-SIG1, L4-GND, L5-PWR/SIG, L6-SIG2, L7-PWR2, L8-SIG3, L9-GND, Bottom Layer), stack 67.57 mil thick; 585 components, 490 nets, 2137 pads, 1150 vias.

## Polygon pours and split planes (outlines as drawn) (continued)
VBOOST_5V on Bottom Layer "AVDD" (solid, pour order 926): 1116.62,1724.38 1128,1713 1192,1713 1199,1720 1199,1741.16 1184.62,1755.53 1184.62,1809.53 1169.62,1824.53 1126.62,1824.53 1116.62,1814.53
BRD_3V3 on Bottom Layer "Bottom Layer-No Net 1" (solid, remove dead copper, pour order 1026): 887.89,2780.41 887.89,2713 877.85,2702.96 877.34,2679.49 881.77,2675.06 1015,2675.06 1029.06,2689.11 1029.06,2750 1024.06,2755 949.37,2755 918.92,2785.45 892.93,2785.45
5V_IN on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 920): 26 vertices, not listed, extent 1719.96,2054.11 1825.96,2259.11
5V_IN on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 918): 33 vertices, not listed, extent 1893.96,2054.11 1996.96,2259.11
5V_IN on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 954): 531,4420 560.42,4420 571.63,4431.21 611.83,4431.21 619.92,4423.12 643.12,4423.12 656.37,4436.37 656.37,4478.18 640.55,4494 521,4494 519.37,4492 519,4491.63 519,4432
NetJ17_58 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 952): 520.24,4610.13 520.24,4549.04 529.28,4540 627,4540 651,4564 651,4630 641,4640 531,4640 519.31,4628.31 519.31,4611.06
5V_IN on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 948): 877.84,3560 900,3582.16 910.58,3592.74 910,3647 910,3730 890,3750 826.37,3750 800,3723.63 800,3580 820,3560
5V_IN on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 946): 726.37,3439.06 719.37,3432.06 719.37,3339.47 730.26,3328.58 730.73,3329.06 818.37,3329.06 829.37,3340.06 829.37,3436.94 807.25,3459.06 746.94,3459.06 726.94,3439.06
GND on Bottom Layer "net" (solid, remove dead copper, pour order 944): 1919.37,25 1924.37,20 2265.31,20 2279.37,34.06 2279.37,84.06 2269.37,94.06 2164.37,94.06 2149.37,109.06 2149.37,206.1 2111.42,244.06 1944.37,244.05 1919.37,219.05
NetD1_1 on Bottom Layer "net" (solid, remove dead copper, pour order 942): 17 vertices, not listed, extent 2169.37,19.06 2569.37,319.06
NetJ12_6 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 940): 25 vertices, not listed, extent 2492.37,3785.3 2743.37,4120.06
WIDE_IN_5V_OP on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 938): 21 vertices, not listed, extent 547,1067.06 751,1226
PMIC_1V2 on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 936): 18 vertices, not listed, extent 1870.22,2352.46 2075.22,2499.46
PMIC_1V0 on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 934): 19 vertices, not listed, extent 1652.22,1550.46 1847.22,1713.65
PMIC_3V3 on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 932): 1854.22,2404.84 1854.22,2477.84 1854.22,2483.84 1850.22,2487.84 1829.01,2509.06 1705.43,2509.06 1692.22,2495.84 1667.22,2470.84 1667.22,2397.84 1667.22,2357.84 1675.22,2349.84 1680.22,2344.84 1716.22,2344.84 1837.22,2344.84 1854.22,2361.84
PMIC_1V8 on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 930): 17 vertices, not listed, extent 1862.22,1555.84 2049.22,1712.46
GND on Bottom Layer "GND_L01_P-001" (solid, remove dead copper, pour order 916): 35 vertices, not listed, extent 1781.65,1716.46 1937.65,2009.68
NetJ11_1 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 912): 2524.44,3384.56 2503.11,3405.89 2474.89,3405.89 2466,3397 2466,3363 2511.63,3317.38 2518.27,3317.38 2620.43,3317.36 2630.93,3327.86 2630.93,3341.19 2622.7,3349.42 2559.58,3349.42
MCU_5V on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 910): 485.55,3612.07 494.07,3603.56 584.87,3603.56 629.37,3559.06 698.75,3559.06 698.75,3559.54 711.06,3571.86 711.06,3678.49 695.5,3694.06 506.55,3694.06 485.55,3673.06
NetJ12_1 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 908): 2551.67,3993.06 2556.45,3997.83 2619.2,3997.83 2620.37,3999 2620.37,4011.06 2618.37,4013.06 2572.2,4013.05 2551.37,4033.89 2551.37,4075.06 2551.37,4125.06 2544.37,4132.06 2484.37,4132.06 2476.37,4124.06 2476.37,4036.43 2519.75,3993.06
FTDI_VBUS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 906): 2349.37,4240.43 2349.37,4157.68 2367.99,4139.06 2534.37,4139.06 2554.37,4159.06 2554.37,4218.55 2520.07,4252.86 2362.34,4252.86 2349.92,4240.43
NetJ11_6 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 904): 18 vertices, not listed, extent 2523.48,3115.06 2755.91,3481.15
XDSET_1_VBUS on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 902): 2449,3354 2440,3345 2375,3345 2368,3352 2368,3416.69 2390.37,3439.06 2436.37,3439.06 2449,3426.43
NetJ10_1 on Bottom Layer "Bottom Layer-No Net" (solid, pour order 900): 675,3295 675,3250 700,3225 810,3225 830,3245 830,3290 810,3310 690,3310
CB_PMIC_1V2 on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 896): 23 vertices, not listed, extent 1699.37,2519.06 2167.37,4150.65
5V_IN on Bottom Layer "net" (solid, remove dead copper, pour order 892): 2413.32,593 2285.43,593 2269.77,608.65 2269.77,706.77 2329,766 2425,766 2440,751 2440,619.68
NetC22_1 on Bottom Layer "net" (solid, remove dead copper, pour order 890): 21 vertices, not listed, extent 1926.38,249.06 2411,594.06
VCC_XDS_3V3 on Bottom Layer "Bottom Layer-No Net 1" (solid, remove dead copper, pour order 1028): 892.63,2953 939.17,2953 947.12,2945.06 947.12,2863.63 933.02,2849.53 892.93,2849.53 886.91,2855.55 886.91,2947.28
5V_IN on Bottom Layer "M1 Board Outline-No Net" (solid, pour order 914): 28 vertices, not listed, extent 1719.96,1798.11 1825.96,2006.11
GND on Bottom Layer "NONET_L-01_P-001" (solid, remove dead copper, pour order 1056): 20 vertices, not listed, extent 68,3766 2387,5261
PMIC_1V8 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 970): 1831.37,1469.06 1810.37,1490.06 1810.37,1533.06 1865.33,1588.02 1865.33,1702.02 1884.37,1721.06 1978.37,1721.06 2009.37,1690.06 2009.37,1547.06 1924.37,1462.06 1924.37,1423.45 1912.98,1412.06 1838.37,1412.06 1831.37,1419.06
NetC96_2 on L3-SIG1 "VS" (solid, pour order 968): 1353.37,1098.06 1519.37,1264.06 1519.37,1433.76 1474.37,1478.76 1419.08,1478.76 1384.37,1444.06 1384.37,1370.33 1244.37,1230.33 1244.37,1134.06 1280.37,1098.06 1280.37,1018.06 1284.37,1014.06 1301.37,997.05 1340.37,997.06 1353.37,1010.06
UNREG_IN1 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 958): 2089.37,680.37 2050,641 2050,476 2071,455 2315,455 2384,524 2384,1491 2285.94,1589.06 2066.37,1589.06 1993.37,1515.8 1993.37,1418.06 1869.37,1293.06 1869.37,1009.06 2087.64,790.79 2089.37,790.79
UNREG_IN2 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 956): 18 vertices, not listed, extent 880.17,689.06 2070.37,1109.06
VCC_XDS_3V3 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 964): 72 vertices, not listed, extent 775,2425.8 1784.37,3934.06
PMIC_1V0 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 966): 1798.14,1529.82 1798.14,1491.29 1821.37,1468.06 1821.37,1435.06 1805.37,1419.06 1658.37,1419.06 1639.37,1438.06 1639.4,1438.08 1639.4,1469.03 1639.37,1469.06 1639.37,1669.06 1689.37,1719.06 1819.37,1719.06 1829.37,1709.06 1829.37,1561.06
CB_PMIC_1V0 on L3-SIG1 "NONET_L-01_P-001" (solid, remove dead copper, pour order 960): 27 vertices, not listed, extent 1539.37,1534 2714.37,3969.06
FTDI_3V3 on L3-SIG1 "L06-PWR2-No Net" (solid, remove dead copper, pour order 962): 54 vertices, not listed, extent 1069.37,2542 1879.37,3819.06
BP_LP_3V3 on L5-PWR/SIG "Bottom Layer-No Net 1" (solid, remove dead copper, pour order 1040): 867.71,3173 851.67,3188.7 692.31,3188.7 677,3173.39 677,3044 773,2948 875.75,2948 907.88,2915.87 907.88,2795.06 916.94,2786 1006,2786 1022,2802 1022,3018.71 977,3063.71
MCU_3V3 on L5-PWR/SIG "VS" (solid, remove dead copper, pour order 978): 17 vertices, not listed, extent 1830,3129 2399,3781
XDSET_1_VBUS on L5-PWR/SIG "NONET_L-01_P-001" (solid, remove dead copper, pour order 976): 21 vertices, not listed, extent 1670.37,2805.06 2755.91,3542.06
5V_IN on L5-PWR/SIG "NONET_L-01_P-001" (solid, remove dead copper, pour order 974): 28 vertices, not listed, extent 485.3,542.71 2669.37,2825.06
MCU_5V on L5-PWR/SIG "GND_L01_P-001" (solid, remove dead copper, pour order 972): 32 vertices, not listed, extent 270.37,1665 793,3695
5V_IN on L5-PWR/SIG "NONET_L-01_P-001" (solid, remove dead copper, pour order 980): 604.37,4434 623.79,4414.58 623.79,4166.52 604,4146.73 604.37,4142 604.37,3895.06 815.37,3684.06 856.37,3684.06 900.37,3728.06 900.37,3787.06 794.37,3893.06 794.37,4431.31 734.62,4491.06 615.37,4491.06 604.37,4480.06
GND on L5-PWR/SIG "GND_L01_P-001" (solid, remove dead copper, pour order 1064): 24 vertices, not listed, extent 22.37,28.06 2729.37,5271.06
BRD_3V3 on L7-PWR2 "GND_L01_P-001" (solid, remove dead copper, pour order 1050): -0.53,4962.96 -0.53,101.96 48.47,52.96 160.47,52.96 628.47,52.96 2384.16,52.96 2691.47,360.28 2691.47,5148.96 2580.47,5259.96 1759.47,5259.96 1752.47,5252.96 289.47,5252.96
VCC_3V3 on L7-PWR2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 990): 61 vertices, not listed, extent 1329.58,590.06 2704.37,2636.03
VBOOST_5V on L7-PWR2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 992): 1129.37,1679.06 1069.37,1679.06 1049.37,1699.06 1049.37,1819.06 1089.37,1859.06 1161,1859.06 1168.18,1867.87 1189.37,1889.06 1389.37,1889.06 1444.37,1834.06 1444.37,1514.06 1419.37,1489.06 1319.37,1489.06
CB_PMIC_1V8 on L7-PWR2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 988): 20 vertices, not listed, extent 1679.37,1379.06 2149.37,4289.06
FTDI_VBUS on L7-PWR2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 986): 18 vertices, not listed, extent 1154.37,2634.06 1574.37,4869.06
VDDC_1 on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 1010): 17 vertices, not listed, extent 1270,2851.06 1869.37,3358.06
FTDI_VBUS on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 996): 2423.37,4135.06 2423.37,4365.34 2444.37,4386.34 2444.37,4454.06 2324.37,4574.06 1289.37,4574.06 1239.37,4624.06 1239.37,4809.06 1314.37,4884.06 2479.37,4884.06 2719.37,4644.06 2719.37,4099.06 2674.37,4054.06 2504.37,4054.06
5V_IN on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 994): 41 vertices, not listed, extent 575.37,2563.06 2410,4660
MCU_3V3 on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 1006): 17 vertices, not listed, extent 1024.37,3694.06 1919.37,3864.06
5V_IN on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 998): 415.37,1982.37 415.37,1561.06 504.37,1472.06 681.37,1472.06 741.37,1532.06 741.37,1765.06 547.37,1959.06 505.37,1959.06 470.43,1994 427,1994
NetJ10_1 on L6-SIG2 "L6-SIG2_NETJ10_1_P1004" (solid, remove dead copper, pour order 1004): 446,3262 485,3301 720,3301 731.37,3289.63 731.37,3244.37 713,3226 668,3226 653,3241 508,3241 485,3218 449.52,3218 438,3229.52 438,3254
FTDI_VCORE on L6-SIG2 "GND_L01_P-001" (solid, remove dead copper, pour order 1002): 24 vertices, not listed, extent 953.37,2901.06 1683.37,3419.06
WIDE_IN_5V_OP on L6-SIG2 "NONET_L-01_P-001" (solid, remove dead copper, pour order 1000): 20 vertices, not listed, extent 559.37,669.06 2704.37,1457.06
NetC78_2 on L8-SIG3 "NONET_L-01_P-001" (solid, remove dead copper, pour order 1024): 1994.37,1177.06 1994.37,1160.63 2004,1151 2105.67,1151 2112.66,1157.99 2112.66,1180.85 2107.51,1186 2003.31,1186
GND on L2-GND "GND_L01_P-001" (solid, remove dead copper, pour order 796): 24 vertices, not listed, extent 22.37,28.06 2729.37,5271.06
GND on L4-GND "GND_L01_P-001" (solid, remove dead copper, pour order 798): 24 vertices, not listed, extent 22.37,28.06 2729.37,5271.06
GND on L9-GND "GND_L01_P-001" (solid, remove dead copper, pour order 800): 24 vertices, not listed, extent 22.37,28.06 2729.37,5271.06

## Keep-outs
Keep-Out Layer:
  text ".Layer_Name" at -303,-1278.49 h60

## Other copper
Top Layer:
  text ".Layer_Name" at -303,-1278.49 h60
L2-GND:
  text "'.Layer_Name'" at -101,-1269 h60
L3-SIG1:
  text "'.Layer_Name'" at -63,-1261 h60
L4-GND:
  text "'.Layer_Name'" at -101,-1265 h60
L5-PWR/SIG:
  text "'.Layer_Name'" at -142,-1258 h60
L6-SIG2:
  text "'.Layer_Name'" at -33,-1265 h60
L7-PWR2:
  text "'.Layer_Name'" at -116,-1273 h60
L8-SIG3:
  text "'.Layer_Name'" at -82,-1269 h60
L9-GND:
  text "'.Layer_Name'" at -97,-1269 h60
Bottom Layer:
  text ".Layer_Name" at -303,-1278.49 h60

## Silkscreen, mask and mechanical layers (free items; w line width, h text height)
Top Overlay:
  drawing of 205 lines, arcs and shapes, not listed
  text "59" at 1732,4655 h60
  text "60" at 822.4,4651.37 h60
  text "59" at 476.04,4647.59 h60
  text "60" at 2123.48,4640 h60
  text "GPIO_2" at 2684.84,4560 h50 r90
  text "FT_VBUS" at 2226.74,4412.31 h45
  text "FT_SUSPND" at 2167.37,4190 h45
  text "FTDI_USB" at 2439.37,4150.31 h70
  text "2" at 849.44,4023.04 h60
  text "1" at 475.71,4021.1 h60
  text "1" at 1761,4019 h60
  text "2" at 2132.37,4001 h60
  text "'.PRJ_Number'.PCB_Rev-" at 893.37,3945 h70
  text "XDS110" at 2502.17,3565.91 h70
  text "1" at 1735.12,3548.99 h45
  text "USB" at 2581.65,3489.22 h70
  text "DCA1000" at 274.06,3478.75 h75
  text "1" at 311.42,3251 h60
  text "2" at 731.63,3235 h60
  text "14 PIN JTAG" at 2435.29,3039.37 h58
  text "14" at 2446.13,2933.04 h55
  text "1" at 1476.01,2756 h45
  text "2" at 195.56,2740 h45
  text "59" at 253.37,2637 h60
  text "60" at 722.31,2630 h60
  text "1" at 900.33,2598.53 h60
  text "S1.12" at 1133.96,2523.21 h40
  text "S1-SWTICH MUX-CONFIG" at 1656,2454 h50
  text "ON" at 1643.37,2402 h50
  text "12" at 1909,2384 h55
  text "GPIO_1" at 2276,2384 h55
  text "XDS110" at 1724,2383 h50
  text "JTAG" at 1988.87,2382.27 h50
  text "OFF" at 2153,2381 h50
  text "11" at 1904.65,2340 h55
  text "FTDI" at 1778.55,2337.25 h50
  text "40PIN" at 1988.87,2337.25 h50
  text "2" at 2454,2313 h55
  text "10" at 1908,2298 h55
  text "FTDI" at 1778.55,2293.56 h50
  text "40PIN" at 1988.87,2293.56 h50
  text "9" at 1933.32,2238 h55
  text "40PIN" at 1773,2230.52 h50
  text "60PIN" at 1994.51,2231.38 h50
  text "8" at 1932,2195.92 h55
  text "60PIN" at 1995,2194 h50
  text "40PIN" at 1776,2192.92 h50
  text "NRST" at 2524.9,2184 h65
  text "FTDI" at 1778.55,2099.06 h50
  text "40/60PIN" at 1977,2089 h50
  text "7" at 1936,2088.06 h55
  text "FTDI" at 1778.55,2049.06 h50
  text "6" at 1934.29,2049.06 h55
  text "40/60PIN" at 1977,2048 h50
  text "XDS110" at 1758,1981 h50
  text "5" at 1935.35,1981 h55
  text "40/60PIN/FTDI" at 1982.9,1975.82 h50
  text "40PIN/FT" at 1755.55,1935 h48
  text "4" at 1936,1935 h55
  text "60PIN" at 1986.37,1935 h50
  text "24" at 794.62,1896.06 h60
  text "59" at 448,1881.69 h60 r90
  text "60" at 84,1874 h60 r90
  text "S1.1" at 1276.13,1871.89 h40 r90
  text "NRST" at 2653.86,1850 h40
  text "FTDI" at 1778.55,1808.43 h50
  text "3" at 1936,1808.43 h55
  text "40PIN" at 1980.9,1808.43 h45
  text "1" at 825.45,1770.13 h60
  text "2" at 1935.35,1722.94 h55
  text "40PIN" at 1798.64,1721.39 h50
  text "CAN_FD" at 2540.27,1716.05 h58
  text "CAN" at 1798.64,1679 h50
  text "SPI-1" at 1993.52,1674.06 h50
  text "1" at 1937.73,1671 h55
  text "CANL" at 2452.9,1591.53 h38 r90
  text "GND" at 2453,1487 h30 r90
  text "CANH" at 2453,1363.74 h32 r90
  text "1" at 429.62,1275.53 h60
  text "2" at 47,1267 h60
  text "VPP_1V7" at 996,1236 h45 r90
  text "CANL" at 2451.9,1174.53 h45 r90
  text "2" at 442.74,1164.89 h45
  text "1" at 878.2,1135.41 h70
  text "MIPI 60PIN" at 90,1095.25 h60
  text "GND" at 2452.9,1078.53 h38 r90
  text "JTAG-TRACE" at 41.37,1047.45 h60
  text "CANH" at 2322.86,808.94 h45
  text "(1-2) : U31 ON" at 713.78,786.91 h45
  text "CAN" at 2439.89,787.2 h58
  text "(2-3) : U31 OFF" at 715.45,742.57 h45
  text "+5V" at 2417.52,705 h55
  text "+3V3" at 2745,665 h55 r90
  text "SOP2" at 37.16,568.77 h60
  text "5V_IN" at 2406,476.17 h45 r90
  text "15" at 1040,455 h60
  text "15" at 1831.37,449.68 h60
  text "10" at 965,421.8 h60
  text "SOP1" at 37.16,368.98 h60
  text "3" at 1266.11,364.81 h60
  text "9" at 970,310 h60
  text "3" at 466,201 h60
  text "SOP0" at 37.16,169.19 h60
  text "3V3" at 1403.81,23.66 h58 r90
  text "NERR" at 1348.91,22.84 h58 r90
  text "SOP1_FT" at 1510.34,22.84 h58 r90
  text "SOP2_FT" at 1457.9,22.02 h58 r90
  text "SOP0_FT" at 1561.97,17.92 h58 r90
  text "NRST_FT" at 1614.51,18.13 h58 r90
  text "5V_IN" at 1288.26,17.1 h58 r90
  text ".Layer_Name" at -303,-1278.49 h60
Bottom Overlay:
  drawing of 745 lines, arcs and shapes, not listed
  text "1" at 1989.63,3735 h75
  text "1" at 280,3705.79 h75
  text "5V" at 660,3703 h60
  text "FTDI_USB" at 2735,3700 h60
  text "GND" at 2379.89,3689.5 h60
  text "3V3" at 223.55,3616.74 h60
  text "SDA" at 1748.63,3597.57 h60 r270
  text "1" at 1886.66,3391.96 h60
  text "1" at 2456.74,3065 h60
  text "XDS110" at 2740,3055 h55
  text "USB" at 2710,3010 h60
  text "SCL" at 2451.11,2919.06 h60 r270
  text "GND" at 225,2533 h80
  text "GND" at 2440.37,2469.24 h75
  text "GND" at 216,2419 h80
  text "GND" at 2445.2,2405.16 h80
  text "5V" at 207,2312 h80
  text "3V3" at 2444.71,2307.17 h50
  text "A" at 2189.1,2145.1 h60
  text "CAN1&2" at 2706,1706 h45 r270
  text "A" at 2309.9,1363.53 h60
  text ".Layer_Name" at -303,-1278.49 h60
Top Paste:
  text ".Layer_Name" at -303,-1278.49 h60
Bottom Paste:
  text ".Layer_Name" at -303,-1278.49 h60
Top Solder:
  text ".Layer_Name" at -303,-1278.49 h60
  text ".Layer_Name" at -303,-1278.49 h60
Bottom Solder:
  text ".Layer_Name" at -303,-1278.49 h60
Drill Guide:
  text ".Layer_Name" at -303,-1278.49 h60
M1 Board Outline:
  the board outline again, w10
  text ".Layer_Name" at -324.31,-1275.96 h60
M2 Board Dimensions:
  rectangle: -755,-820 -380,-695
  rectangle: -880,-695 -755,-570
  lines w7: -880,-695 120,-695 ; -755,-820 -755,-570 ; -630,-820 -630,-570 ; -380,-820 -380,-570 ; -130,-820 -130,-570 ; -880,-820 -880,-570 120,-570 120,-820 -880,-820
M3 3D STEP Top:
  text ".Layer_Name" at -303,-1278.49 h60
M4 3D STEP Bottom:
  text ".Layer_Name" at -303,-1278.49 h60
M5 Assembly Top:
  lines w10: -1172,-1350.17 5428,-1350.17 ; -1172,-1146.83 5430,-1146.83 ; -1172,-943.5 -1172,-1553.5 2833,-1553.5 5430,-1553.5 5430,-943.5 -1171.5,-943.5 -1171.5,-1553.5 404,-1553.5 ; 1293,-1553.5 1293,-943.5 ; 2560,-1146.83 2560,-943.5 ; 3400,-1146.83 3400,-943.5 ; 4022,-1560 4022,-1357.17
  text "59" at 484.77,4660.54 h45
  text "60" at 802.6,4646.55 h45
  text "60" at 2090.82,4642.11 h45
  text "59" at 1793.42,4640.89 h45
  text "2" at 849.42,4026.87 h45
  text "1" at 490.2,4017.57 h45
  text "1" at 1809.81,4013.93 h45
  text "2" at 2092.03,4013.32 h45
  text "1" at 343.99,3257.47 h45
  text "2" at 671.44,3255.62 h45
  text "13" at 2673.03,2917.81 h50 r90
  text "14" at 2574.67,2915.77 h50 r90
  text "59" at 322.41,2631.55 h45
  text "60" at 668.98,2629.09 h45
  text "1" at 1013.33,2541.64 h45 r90
  text "1" at 2670.32,2332.41 h50 r90
  text "2" at 2572.64,2330.37 h50 r90
  text "S1" at 1020.86,2199.51 h45
  text "59" at 411.44,1877.12 h45
  text "60" at 57.36,1875.88 h45
  text "1" at 900.67,1760.08 h45 r90
  text "3" at 2685.25,1620.17 h50 r90
  text "2" at 2686.6,1480.43 h50 r90
  text "1" at 2689.31,1335.94 h50 r90
  text "2" at 80.75,1271.43 h45
  text "1" at 416.3,1267.6 h45
  text "3" at 2685.25,1175.17 h50 r90
  text "1" at 879.17,1139.71 h45
  text "2" at 2686.6,1035.43 h50 r90
  text "1" at 2689.31,890.94 h50 r90
  text "2" at 344.3,644.02 h50
  text "16" at 1032.13,641.32 h50
  text "2" at 1150.84,640.63 h50
  text "16" at 1840.71,637.24 h50
  text "3" at 2562.96,560.56 h45
  text "15" at 1032.13,544.99 h50
  text "15" at 1842.06,536.16 h50
  text "2" at 491.99,422.02 h50
  text "2" at 491.99,422.02 h50
  text "10" at 881.11,420.79 h50
  text "9" at 895.9,322.12 h50
  text "2" at 2674.9,316.32 h45
  text "1" at 2479.23,310.76 h45
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 273.5,-738.5 h60
  text "ASSEMBLY VARIANT:" at 273,-854 h60
  text ".VariantName" at 1309,-854 h60
  text "PCB VIEWED FROM TOP SIDE" at -1108.5,-1075.67 h60
  text "BOARD #:" at 1368,-1075.67 h60
  text ".PRJ_Number" at 1913.5,-1075.67 h60
  text "REV:" at 2758,-1075.67 h60
  text ".PCB_Rev" at 3049.5,-1075.67 h60
  text "SVN REV:" at 3596,-1075.67 h60
  text ".VersionControl_RevNumber" at 4102,-1075.67 h60
  text "'.Layer_Name'" at -126,-1260 h60
  text "LAYER NAME =" at -1112.48,-1276.64 h60
  text "TID #:" at 1368,-1279 h60
  text ".TID" at 1913.5,-1279 h60
  text "PLOT NAME =" at -1108.5,-1484.34 h60
  text ".plot_File_Name" at -303,-1484.34 h60
  text "GENERATED    :" at 1370,-1484.34 h60
  text ".Print_Date" at 2239.5,-1484.34 h60
  text ".Print_Time" at 2968.5,-1484.34 h60
  text "TEXAS INSTRUMENTS" at 4233,-1484.34 h60
M6 Assembly Bottom:
  circle w10: c2565.47,4006.45 r5.09
  circle w10: c2565.47,3331.45 r5.09
  circle w10: c453.9,2579.51 r6.99
  circle w10: c2237.75,2575.72 r8.17
  lines w10: -1172.5,-1147.33 5429.5,-1147.33 ; -1170.5,-1350.67 5429.5,-1350.67 ; 235.5,-1560.5 235.5,-1357.67 ; 857.5,-1147.33 857.5,-944 ; 1697.5,-1147.33 1697.5,-944 ; 2964.5,-1554 2964.5,-944 ; 3853.5,-1554 5429,-1554 5429,-944 -1172.5,-944 -1172.5,-1554 1424.5,-1554 5429.5,-1554 5429.5,-944
  text "1" at 307.91,3662.58 h45
  text "2" at 2252.33,3663.2 h45
  text "1" at 2006.69,3661.79 h45
  text "2" at 552.18,3660.65 h45
  text "1" at 1949.78,3470.3 h45
  text "1" at 2460.11,3061.63 h45
  text "19" at 309.82,2698.07 h45
  text "20" at 571.93,2696.66 h45
  text "19" at 2011.87,2695.71 h45
  text "20" at 2267.39,2695.71 h45
  text "COMPONENTS MARKED 'DNP' SHOULD NOT BE POPULATED." at 5222,-738 h60
  text ".VariantName" at 4178,-854 h60
  text "ASSEMBLY VARIANT:" at 5217,-854 h60
  text ".VersionControl_RevNumber" at 155.5,-1076.17 h60
  text "SVN REV:" at 661.5,-1076.17 h60
  text ".PCB_Rev" at 1208,-1076.17 h60
  text "REV:" at 1499.5,-1076.17 h60
  text ".PRJ_Number" at 2344,-1076.17 h60
  text "BOARD #:" at 2889.5,-1076.17 h60
  text "PCB VIEWED FROM BOTTOM SIDE" at 5366,-1076.17 h60
  text "LAYER NAME =" at 5304.23,-1267.15 h60
  text "'.Layer_Name'" at 4488.48,-1274.84 h60
  text ".TID" at 2344,-1279.5 h60
  text "TID #:" at 2889.5,-1279.5 h60
  text ".plot_File_Name" at 4258,-1483 h60
  text "TEXAS INSTRUMENTS" at 24.5,-1484.84 h60
  text ".Print_Time" at 1289,-1484.84 h60
  text ".Print_Date" at 2018,-1484.84 h60
  text "GENERATED    :" at 2887.5,-1484.84 h60
  text "PLOT NAME =" at 5366,-1484.84 h60
M7 LPKF Text Top:
  lines w0.98: 14.41,2269.95 812.41,2269.95 812.41,3651.23 14.41,3651.23
  lines w4: 251.26,3760.95 2416.61,3760.95 ; 251.26,5926.3 2416.61,5926.3
  lines w4.02: 251.26,3760.95 251.26,5926.3 ; 2416.61,3760.95 2416.61,5926.3
M9 Title Sheet:
  lines w10: -1371.5,621.5 -1171.5,621.5 ; -1371.5,2996.5 -1171.5,2996.5 ; -1371.5,5371.5 -1171.5,5371.5 ; 1128.5,-1753.5 1128.5,-1553.5 ; 1128.5,7546.5 1128.5,7746.5 ; 3628.5,-1753.5 3628.5,-1553.5 ; 3628.5,7546.5 3628.5,7746.5 ; 5441,-1553.5 5441,-943.5 10423.5,-943.5 ; 6128.5,-1753.5 6128.5,-1553.5 ; 6128.5,7546.5 6128.5,7746.5 ; 8628.5,-1753.5 8628.5,-1553.5 ; 8628.5,7546.5 8628.5,7746.5 ; 10423.5,-1553.5 10423.5,-943.5 ; 10423.5,-1243.5 13423.5,-1243.5 ; 10423.5,-643.5 13423.5,-643.5 ; 10424.5,-49.5 13424.5,-49.5 ; 11128.5,-1753.5 11128.5,-1553.5 ; 11128.5,7546.5 11128.5,7746.5 ; 11928.5,-1543.5 11928.5,-943.5 ; 13423.5,-943.5 10423.5,-943.5 ; 13423.5,-343.5 10423.5,-343.5 ; 13428.5,-353.5 13428.5,-1553.5 ; 13428.5,451 10424.5,451 10423.5,451 10423.5,-49.5 10423.5,-343.5 ; 13428.5,621.5 13628.5,621.5 ; 13428.5,2996.5 13628.5,2996.5 ; 13428.5,5371.5 13628.5,5371.5 ; 10423.5,-943.5 10423.5,-343.5 ; 13428.5,-1553.5 -1171.5,-1553.5 -1171.5,7546.5 13428.5,7546.5 13428.5,-1553.5 ; -1371.5,-1753.5 13628.5,-1753.5 13628.5,7746.5 -1371.5,7746.5 -1371.5,-1753.5
  text "1" at -140.16,7616.5 h70
  text "2" at 2355.5,7616.5 h70
  text "3" at 4844.84,7616.5 h70
  text "4" at 7351.51,7616.5 h70
  text "5" at 9850.5,7616.5 h70
  text "6" at 12355.5,7616.5 h70
  text "A" at -1296.5,6473.5 h70
  text "A" at 13503.5,6473.5 h70
  text "B" at -1296.5,4093.5 h70
  text "B" at 13503.5,4093.5 h70
  text "C" at -1296.5,1718.5 h70
  text "C" at 13503.5,1718.5 h70
  text "PROJECT TITLE:" at 10463.5,-142.5 h45
  text ".PRJ_Title" at 10513.5,-275.83 h70
  text "DESIGNED FOR:" at 10463.5,-443.5 h45
  text ".PRJ_Customer" at 10513.5,-583.5 h70
  text "D" at -1296.5,-651.5 h70
  text "D" at 13503.5,-651.5 h70
  text "FILE NAME:" at 10463.5,-743.5 h45
  text ".PCB_File_Name_No_Path" at 10513.5,-863.5 h70
  text "Texas Instruments (TI) and/or its licensors do not warrant the accuracy or completeness of this specification" at 5494,-1025.34 h45
  text "ENGINEER:" at 10463.5,-1033.5 h45
  text "LAYOUT BY:" at 11968.5,-1033.5 h45
  text "or any information contained therein. TI and/or its licensors do not warrant that this design will meet" at 5449.01,-1138 h45
  text ".PRJ_Engineer" at 10513.5,-1188.49 h70
  text ".PCB_Layout" at 12019,-1188.49 h70
  text "the specifications, will be suitable for your application or fit for any particular purpose, or will operate in" at 5449.01,-1250.67 h45
  text "ALTIUM DESIGNER VERSION:" at 11968.5,-1343.5 h45
  text "an implementation. TI and/or its licensors do not warrant that the design is production worthy. You should" at 5449.01,-1363.33 h45
  text "completely validate and test your design implementation to confirm the system functionality for your application." at 5494,-1476 h45
  text ".print_Scale" at 10513.5,-1476.83 h70
  text ".Application_BuildNumber" at 12019,-1476.83 h70
  text "1" at -140.16,-1683.5 h70
  text "2" at 2355.5,-1683.5 h70
  text "3" at 4844.84,-1683.5 h70
  text "4" at 7351.51,-1683.5 h70
  text "5" at 9850.5,-1683.5 h70
  text "6" at 12355.5,-1683.5 h70
M10 Fab Notes:
  drawing of 189 lines, arcs and shapes, not listed
  text "DESIGN INFORMATION" at 11502.02,5936.17 h60
  text "MIN. TRACK WIDTH:" at 10857.46,5804.05 h60
  text "4" at 11953.7,5804.05 h60
  text "MIL" at 12108.46,5804.05 h60
  text "4" at 11952,5683 h60
  text "MIN. CLEARANCE:" at 10857.46,5679.92 h60
  text "MIL" at 12108.46,5679.92 h60
  text "MIN. VIA PAD SIZE:" at 10857.46,5555.8 h60
  text "15.78" at 11923.71,5555.8 h60
  text "MIL" at 12203,5555 h60
  text "0.05mm (2MIL)" at 11552.46,5425.9 h60
  text "MINIMUM ANNULAR RING" at 10528.23,5417.67 h60
  text "EXTERNAL" at 12260.46,5417.67 h60
  text "PER" at 10728.23,5307.55 h60
  text "IPC-D-275 CLASS 2 LEVEL C" at 10948.23,5307.54 h60
  text "MIL, HOLES" at 12436.46,5207.07 h60
  text "+/-" at 12044,5198.48 h60
  text "+/-" at 12898,5198.48 h60
  text "REGISTRATION TOLERANCES:" at 10528.23,5197.42 h60
  text "METAL" at 11728,5197.42 h60
  text "5" at 12304.2,5197.42 h60
  text "3" at 13137.2,5197.42 h60
  text "MIL" at 13253.46,5197.42 h60
  text "HOLE SIZE TOLERANCE (UNLESS OTHERWISE SPECIFIED):" at 10528.23,5099.1 h60
  text "+/-" at 12898,5096.23 h60
  text "3" at 13137.2,5095.17 h60
  text "MIL" at 13253.46,5095.17 h60
  text "MATERIAL:" at 10453.46,4957.52 h60
  text "FR-4" at 12723,4838 h60
  text "FR-4 High Tg" at 11439.9,4829 h60
  text "X" at 12186,4825 h60
  text "FR-408" at 10874.46,4816.49 h60
  text "OTHER" at 12362.46,4816.49 h60
  text "62 MIL (1.6mm) +/-10%" at 11194.56,4673.46 h60
  text "69.17MILS +/-10%" at 12762.27,4671.36 h48
  text "X" at 12358,4667 h60
  text "THICKNESS:" at 10528.23,4665.24 h60
  text "OTHER" at 12479.46,4665.24 h60
  text "TOLERANCE:" at 10528.23,4526.92 h60
  text "X" at 11376.46,4526.92 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 11554.48,4526.92 h60
  text "OTHER +/-" at 11554.46,4382.73 h60
  text "BOW & TWIST:" at 10528.23,4237.54 h60
  text "X" at 11376.46,4237.54 h60
  text "ANSI IPC-6012 TYPE 3 CLASS 2" at 11554.48,4237.54 h60
  text "OTHER +/-" at 11554.46,4090.85 h60
  text "DRILLING:" at 10453.46,3960.23 h60
  text "NC_DRILL FILES" at 12214.46,3855.04 h60
  text "REFERENCE:" at 10528.23,3851.1 h60
  text "X" at 11185.46,3851.01 h60
  text "AS SHOWN" at 11363.46,3851.1 h60
  text "X" at 12086.46,3851.1 h60
  text "OTHER" at 12512.46,3708.85 h60
  text "PTH COPPER THICKNESS:" at 10527.91,3705.32 h60
  text "20-30 um" at 11795.14,3705.32 h60
  text "X" at 11667,3701 h60
  text "Notes :" at 6199,3617 h60
  text "BOARD FINISH:" at 10453.46,3557.73 h60
  text "All vias are tented on both the sides excepet thermal via's" at 6339,3541 h60
  text "SILKSCREEN:" at 10608.68,3447.6 h60
  text "X" at 11566.46,3447.6 h60
  text "TOP" at 11683.46,3447.6 h60
  text "X" at 12076.46,3447.6 h60
  text "BOTTOM" at 12194.46,3447.6 h60
  text "SILKSCREEN COLOR:" at 10608.68,3292.41 h60
  text "X" at 11565.46,3292.41 h60
  text "WHITE" at 11683.46,3292.41 h60
  text "OTHER" at 12194.46,3292.41 h60
  text "RED" at 12826.46,3151.36 h60
  text "GREEN" at 11814.46,3148.96 h60
  text "X" at 12288.46,3148.96 h60
  text "OTHER" at 12432.46,3148.96 h60
  text "SOLDER RESIST COLOR:" at 10608.68,3142.1 h60
  text "MATTE" at 11814.46,2994.71 h60
  text "SEMI-GLOSS" at 12432,2994.07 h60
  text "IMMERSION GOLD (ENIG)" at 11514.46,2821.94 h60
  text "ENEPIG" at 12852,2814.72 h60
  text "SURFACE FINISH:" at 10453.46,2813.72 h60
  text "X" at 11336.46,2813.72 h60
  text "IMM. TIN/SILVER OR EQUIV" at 10783,2676.4 h60
  text "OTHER" at 12214.46,2672.47 h60
  text "ARRAY/PANEL:" at 10453.46,2517.09 h60
  text "CUT AND TRIM PER M1 BOARD OUTLINE" at 11514.46,2508.87 h60
  text "N.C. ROUTE" at 11514.46,2372.9 h60
  text "V. SCORE" at 12380.46,2372.9 h60
  text "CERTIFICATION:" at 10453.46,2243.77 h60
  text "MATERIALS AND WORKMANSHIP FOR ALL PCBS" at 11178.46,2243.77 h60
  text "TO MEET OR EXCEED THE REQUIREMENTS OF:" at 11178.46,2149.71 h60
  text "X" at 10815.97,2021.08 h60
  text "ANSI IPC-A-600F CLASS ->" at 10943.96,2021.08 h60
  text "X" at 12591.97,2021.08 h60
  text "2" at 12701.96,2021.08 h60
  text "1" at 12386.96,2019.58 h60
  text "3" at 13055.96,2019.58 h60
  text "X" at 11627.97,1873.39 h60
  text "RoHS" at 11755.96,1873.39 h60
  text "OTHER" at 12400.36,1873.39 h60
  text "PER ORDER" at 12797.42,1873.39 h60
  text "ALL BOARDS MUST MEET OR EXCEED UL94-V0 REQUIREMENTS." at 10481,1719.57 h60
  text "PCB MUST BEAR THE UL94V-0 UL REGISTERED MATERIAL ID NUMBER" at 10481,1603.5 h60
  text "ADDITIONAL REQUIREMENTS:" at 10453.46,1434.08 h60
  text "MICROSECTION:" at 10528.23,1326.95 h60
  text "YES" at 11433.96,1326.95 h60
  text "REQUIRED" at 12295.46,1182.62 h60
  text "BARE BOARD ELEC. TEST:" at 10528.23,1179.76 h60
  text "NONE" at 11833.96,1179.76 h60
  text "X" at 12177.46,1179.76 h60
  text "PER ORDER" at 12887.46,1179.76 h60
  text "XX MIL VIAS REQUIRE NON-CONDUCTIVE FILL AND PLANARIZE" at 10696.38,974.82 h59
  text "XX MIL VIAS REQUIRE CONDUCTIVE FILL AND PLANARIZE" at 10704.38,870.84 h60
  text "OUTER XX MIL TRACES REQUIRE 50 OHM SINGLE-ENDED IMPEDANCE" at 10703.39,707.46 h52
  text "LAYER 2 & 3 (INNER LAYERS) XX MIL WIDE, XX MIL SPACE / TRACES REQUIRE 100 OHM DIFFERENTIAL IMPEDANCE" at 10695.39,471.74 h60
  text ".Layer_Name" at -289.04,-1275.39 h60
M11 Gerber Information:
  lines w10: -1172,-1350.17 5428,-1350.17 ; -1172,-1146.83 5430,-1146.83 ; -1172,-943.5 -1172,-1553.5 2833,-1553.5 5430,-1553.5 5430,-943.5 -1171.5,-943.5 -1171.5,-1553.5 404,-1553.5 ; 1293,-1553.5 1293,-943.5 ; 2560,-1146.83 2560,-943.5 ; 3400,-1146.83 3400,-943.5 ; 4022,-1560 4022,-1357.17
  text "ALL ARTWORK VIEWED FROM TOP SIDE" at -1108.5,-1075.67 h60
  text "BOARD #:" at 1368,-1075.67 h60
  text ".PRJ_Number" at 1913.5,-1075.67 h60
  text "REV:" at 2758,-1075.67 h60
  text ".PCB_Rev" at 3049.5,-1075.67 h60
  text "SVN REV:" at 3596,-1075.67 h60
  text ".VersionControl_RevNumber" at 4102,-1075.67 h60
  text "LAYER NAME =" at -1108.5,-1278.49 h60
  text "TID #:" at 1368,-1279 h60
  text ".TID" at 1913.5,-1279 h60
  text "PLOT NAME =" at -1108.5,-1484.34 h60
  text ".plot_File_Name" at -303,-1484.34 h60
  text "GENERATED    :" at 1370,-1484.34 h60
  text ".Print_Date" at 2239.5,-1484.34 h60
  text ".Print_Time" at 2968.5,-1484.34 h60
  text "TEXAS INSTRUMENTS" at 4233,-1484.34 h60
M12 Stackup:
  drawing of 585 lines, arcs and shapes, not listed
  text "Layer" at 6000.21,7327.5 h70
  text "Name" at 6403.16,7327.5 h70
  text "Material" at 7292,7327.5 h70
  text "Thickness" at 8061.54,7327.5 h70
  text "Constant" at 8657.78,7327.5 h70
  text "Board Layer Stack" at 9229.35,7327.5 h70
  text "IMPEDANCE TABLE" at -709.69,7305.66 h80
  text "1" at 6000.21,7187.5 h70
  text "Top Overlay" at 6403.16,7187.5 h70
  text "SPACING" at 3628.9,7140.3 h70
  text "LAYER" at 2878.9,7135.3 h70
  text "TRACE WIDTH" at 3143.9,7135.3 h70
  text "IMPEDANCE +/- 10%" at 3963.9,7135.3 h70
  text "REFERENCE LAYER" at 4688.9,7135.3 h70
  text "LAYER" at -831.2,7100.5 h70
  text "TRACE WIDTH" at -566.2,7100.5 h70
  text "IMPEDANCE +/- 10%" at -78.2,7100.5 h70
  text "REFERENCE LAYER" at 646.8,7100.5 h70
  text "2" at 6000.21,7047.5 h70
  text "Top Solder" at 6403.16,7047.5 h70
  text "Solder Resist" at 7292,7047.5 h70
  text "0.80mil" at 8061.54,7047.5 h70
  text "1" at 8657.78,7047.5 h70
  text "LAYER-2" at 4721.5,6967.5 h65
  text "4.99 MILS" at 3243.3,6963.6 h65
  text "TOP" at 2847.2,6959.7 h70
  text "6.01 MILS" at 3631.2,6958.4 h65
  text "90 OHM" at 4101.3,6957.8 h65
  text "TOP" at -796.2,6950.5 h70
  text "50 OHM" at 31.8,6945.5 h65
  text "LAYER-2" at 748.5,6941.6 h65
  text "6 MILS" at -471,6941.3 h65
  text "3" at 6000.21,6907.5 h70
  text "Top Layer" at 6403.16,6907.5 h70
  text "Copper" at 7292,6907.5 h70
  text "1.80mil" at 8061.54,6907.5 h70
  text "Layer-3" at -835.3,6795 h70
  text "LAYER-9" at 4721.4,6790 h65
  text "50 OHM" at 35.3,6789.1 h65
  text "LAYER-4" at 750.3,6787 h65
  text "4 MILS" at -479.5,6786.2 h65
  text "6.01 MILS" at 3621,6785.7 h65
  text "4.99 MILS" at 3226.1,6781.3 h65
  text "90 OHM" at 4107.3,6779.9 h65
  text "BOTTOM" at 2818.2,6776.2 h60
  text "4" at 6000.21,6767.5 h70
  text "Dielectric1" at 6403.16,6767.5 h70
  text "FR-4" at 7292,6767.5 h70
  text "3.87mil" at 8061.54,6767.5 h70
  text "4.02" at 8657.78,6767.5 h70
  text "LAYER-4" at 738,6651.7 h65
  text "50 OHM" at 45.9,6639.8 h65
  text "4.5 MILS" at -485.9,6635.3 h65
  text "Layer5" at -823.8,6633.1 h70
  text "5" at 6000.21,6627.5 h70
  text "L2-GND" at 6403.16,6627.5 h70
  text "Copper" at 7292,6627.5 h70
  text "1.20mil" at 8061.54,6627.5 h70
  text "LAYER-7" at 745,6500.7 h65
  text "4.5 MILS" at -490.1,6490.5 h65
  text "50 OHM" at 52.9,6490.5 h65
  text "6" at 6000.21,6487.5 h70
  text "Dielectric 2" at 6403.16,6487.5 h70
  text "FR-4" at 7292,6487.5 h70
  text "4.00mil" at 8061.54,6487.5 h70
  text "4.26" at 8657.78,6487.5 h70
  text "Layer-6" at -832.3,6486.5 h70
  text "SPACING" at 3630.5,6411.5 h70
  text "LAYER" at 2880.5,6406.5 h70
  text "TRACE WIDTH" at 3145.5,6406.5 h70
  text "IMPEDANCE +/- 10%" at 3965.5,6406.5 h70
  text "REFERENCE LAYER" at 4690.5,6406.5 h70
  text "50 OHM" at 65.2,6353.5 h65
  text "LAYER-9" at 746.8,6347.9 h65
  text "7" at 6000.21,6347.5 h70
  text "L3-SIG1" at 6403.16,6347.5 h70
  text "Copper" at 7292,6347.5 h70
  text "1.20mil" at 8061.54,6347.5 h70
  text "4 MILS" at -474.1,6342.6 h65
  text "Layer-8" at -832.5,6333.8 h70
  text "100 OHM" at 4079.1,6244.3 h65
  text "LAYER-2" at 4717.5,6241 h65
  text "8.99 MILS" at 3638.2,6228.4 h65
  text "5.01 MILS" at 3234.2,6221.4 h65
  text "TOP" at 2870.7,6219.2 h70
  text "8" at 6000.21,6207.5 h70
  text "Dielectric 3" at 6403.16,6207.5 h70
  text "FR-4" at 7292,6207.5 h70
  text "8.70mil" at 8061.54,6207.5 h70
  text "4.06" at 8657.78,6207.5 h70
  text "6 MILS" at -467.3,6206 h65
  text "50 OHM" at 75.7,6206 h65
  text "Bottom" at -831.8,6197.7 h70
  text "LAYER-9" at 745,6189.8 h65
  text "9" at 6000.21,6067.5 h70
  text "L4-GND" at 6403.16,6067.5 h70
  text "Copper" at 7292,6067.5 h70
  text "1.20mil" at 8061.54,6067.5 h70
  text "11.99 MILS" at 3624.2,6054.5 h65
  text "Layer-3" at 2844,6052.6 h60
  text "4.01 MILS" at 3234.2,6051 h65
  text "LAYER-4" at 4701,6049.3 h65
  text "100 OHM" at 4087.9,6047.5 h65
  text "10" at 6000.21,5927.5 h70
  text "Dielectric 4" at 6403.16,5927.5 h70
  text "FR-4" at 7292,5927.5 h70
  text "4.00mil" at 8061.54,5927.5 h70
  text "4.26" at 8657.78,5927.5 h70
  text "11" at 6000.21,5787.5 h70
  text "L5-PWR/SIG" at 6403.16,5787.5 h70
  text "Copper" at 7292,5787.5 h70
  text "1.20mil" at 8061.54,5787.5 h70
  text "12" at 6000.21,5647.5 h70
  text "Dielectric 5" at 6403.16,5647.5 h70
  text "FR-4" at 7292,5647.5 h70
  text "13.51mil" at 8061.54,5647.5 h70
  text "4.06" at 8657.78,5647.5 h70
  text "13" at 6000.21,5507.5 h70
  text "L6-SIG2" at 6403.16,5507.5 h70
  text "Copper" at 7292,5507.5 h70
  text "1.20mil" at 8061.54,5507.5 h70
  text "14" at 6000.21,5367.5 h70
  text "Dielectric 6" at 6403.16,5367.5 h70
  text "FR-4" at 7292,5367.5 h70
  text "4.00mil" at 8061.54,5367.5 h70
  text "4.26" at 8657.78,5367.5 h70
  text "15" at 6000.21,5227.5 h70
  text "L7-PWR2" at 6403.16,5227.5 h70
  text "Copper" at 7292,5227.5 h70
  text "1.20mil" at 8061.54,5227.5 h70
  text "16" at 6000.21,5087.5 h70
  text "Dielectric 7" at 6403.16,5087.5 h70
  text "FR-4" at 7292,5087.5 h70
  text "8.42mil" at 8061.54,5087.5 h70
  text "4.06" at 8657.78,5087.5 h70
  text "17" at 6000.21,4947.5 h70
  text "L8-SIG3" at 6403.16,4947.5 h70
  text "Copper" at 7292,4947.5 h70
  text "1.20mil" at 8061.54,4947.5 h70
  text "18" at 6000.21,4807.5 h70
  text "Dielectric 8" at 6403.16,4807.5 h70
  text "FR-4" at 7292,4807.5 h70
  text "4.00mil" at 8061.54,4807.5 h70
  text "4.26" at 8657.78,4807.5 h70
  text "19" at 6000.21,4667.5 h70
  text "L9-GND" at 6403.16,4667.5 h70
  text "Copper" at 7292,4667.5 h70
  text "1.20mil" at 8061.54,4667.5 h70
  text "20" at 6000.21,4527.5 h70
  text "Dielectric 9" at 6403.16,4527.5 h70
  text "FR-4" at 7292,4527.5 h70
  text "3.87mil" at 8061.54,4527.5 h70
  text "4.02" at 8657.78,4527.5 h70
  text "21" at 6000.21,4387.5 h70
  text "Bottom Layer" at 6403.16,4387.5 h70
  text "Copper" at 7292,4387.5 h70
  text "1.80mil" at 8061.54,4387.5 h70
  text "22" at 6000.21,4247.5 h70
  text "Bottom Solder" at 6403.16,4247.5 h70
  text "Solder Resist" at 7292,4247.5 h70
  text "0.80mil" at 8061.54,4247.5 h70
  text "1" at 8657.78,4247.5 h70
  text "23" at 6000.21,4107.5 h70
  text "Bottom Overlay" at 6403.16,4107.5 h70
  text ".Layer_Name" at -234.46,-1278.88 h60
M14 Component Bodies Bottom:
  text ".Layer_Name" at -303,-1278.49 h60
M15 Courtyards Top:
  text ".Layer_Name" at -303,-1278.49 h60
M16 Courtyards Bottom:
  text ".Layer_Name" at -303,-1278.49 h60
Drill Drawing:
  drawing of 185 lines, arcs and shapes, not listed
  text "Symbol" at 3236.2,3115.55 h72
  text "Count" at 3693.79,3115.55 h72
  text "Hole Size" at 4234.26,3115.55 h72
  text "Plated" at 5222.08,3115.55 h72
  text "Hole Type" at 5618.99,3115.55 h72
  text "Drill Layer Pair" at 6208.2,3115.55 h72
  text "Routed Path Length" at 7440.82,3115.55 h72
  text "Hole Length" at 8528.1,3115.55 h72
  text "4" at 3693.79,2965.55 h60
  text "170.00mil (4.318mm)" at 4234.26,2965.55 h60
  text "NPTH" at 5222.08,2965.55 h60
  text "Round" at 5618.99,2965.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2965.55 h60
  text "-" at 7440.82,2965.55 h60
  text "-" at 8528.1,2965.55 h60
  text "2" at 3693.79,2815.55 h60
  text "125.20mil (3.180mm)" at 4234.26,2815.55 h60
  text "NPTH" at 5222.08,2815.55 h60
  text "Round" at 5618.99,2815.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2815.55 h60
  text "-" at 7440.82,2815.55 h60
  text "-" at 8528.1,2815.55 h60
  text "2" at 3693.79,2665.55 h60
  text "118.11mil (3.000mm)" at 4234.26,2665.55 h60
  text "NPTH" at 5222.08,2665.55 h60
  text "Round" at 5618.99,2665.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2665.55 h60
  text "-" at 7440.82,2665.55 h60
  text "-" at 8528.1,2665.55 h60
  text "6" at 3693.79,2515.55 h60
  text "118.11mil (3.000mm)" at 4234.26,2515.55 h60
  text "PTH" at 5222.08,2515.55 h60
  text "Round" at 5618.99,2515.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2515.55 h60
  text "-" at 7440.82,2515.55 h60
  text "-" at 8528.1,2515.55 h60
  text "1" at 3693.79,2365.55 h60
  text "80.00mil (2.032mm)" at 4234.26,2365.55 h60
  text "PTH" at 5222.08,2365.55 h60
  text "Round" at 5618.99,2365.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2365.55 h60
  text "-" at 7440.82,2365.55 h60
  text "-" at 8528.1,2365.55 h60
  text "6" at 3693.79,2215.55 h60
  text "47.24mil (1.200mm)" at 4234.26,2215.55 h60
  text "PTH" at 5222.08,2215.55 h60
  text "Round" at 5618.99,2215.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2215.55 h60
  text "-" at 7440.82,2215.55 h60
  text "-" at 8528.1,2215.55 h60
  text "4" at 3693.79,2065.55 h60
  text "40.16mil (1.020mm)" at 4234.26,2065.55 h60
  text "NPTH" at 5222.08,2065.55 h60
  text "Round" at 5618.99,2065.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,2065.55 h60
  text "-" at 7440.82,2065.55 h60
  text "-" at 8528.1,2065.55 h60
  text "28" at 3693.79,1915.55 h60
  text "40.16mil (1.020mm)" at 4234.26,1915.55 h60
  text "PTH" at 5222.08,1915.55 h60
  text "Round" at 5618.99,1915.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1915.55 h60
  text "-" at 7440.82,1915.55 h60
  text "-" at 8528.1,1915.55 h60
  text "4" at 3693.79,1765.55 h60
  text "40.00mil (1.016mm)" at 4234.26,1765.55 h60
  text "NPTH" at 5222.08,1765.55 h60
  text "Round" at 5618.99,1765.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1765.55 h60
  text "-" at 7440.82,1765.55 h60
  text "-" at 8528.1,1765.55 h60
  text "55" at 3693.79,1615.55 h60
  text "40.00mil (1.016mm)" at 4234.26,1615.55 h60
  text "PTH" at 5222.08,1615.55 h60
  text "Round" at 5618.99,1615.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1615.55 h60
  text "-" at 7440.82,1615.55 h60
  text "-" at 8528.1,1615.55 h60
  text "4" at 3693.79,1465.55 h60
  text "33.47mil (0.850mm)" at 4234.26,1465.55 h60
  text "PTH" at 5222.08,1465.55 h60
  text "Round" at 5618.99,1465.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1465.55 h60
  text "-" at 7440.82,1465.55 h60
  text "-" at 8528.1,1465.55 h60
  text "1123" at 3693.79,1315.55 h60
  text "12.20mil (0.310mm)" at 4234.26,1315.55 h60
  text "PTH" at 5222.08,1315.55 h60
  text "Round" at 5618.99,1315.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1315.55 h60
  text "-" at 7440.82,1315.55 h60
  text "-" at 8528.1,1315.55 h60
  text "A" at 3207.11,1305.56 h66.67
  text "27" at 3693.79,1165.55 h60
  text "7.87mil (0.200mm)" at 4234.26,1165.55 h60
  text "PTH" at 5222.08,1165.55 h60
  text "Round" at 5618.99,1165.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1165.55 h60
  text "-" at 7440.82,1165.55 h60
  text "-" at 8528.1,1165.55 h60
  text "4" at 3693.79,1015.55 h60
  text "23.62mil (0.600mm)" at 4234.26,1015.55 h60
  text "PTH" at 5222.08,1015.55 h60
  text "Slot" at 5618.99,1015.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,1015.55 h60
  text "27.56mil (0.700mm)" at 7440.82,1015.55 h60
  text "51.18mil (1.300mm)" at 8528.1,1015.55 h60
  text "2" at 3693.79,865.55 h60
  text "39.37mil (1.000mm)" at 4234.26,865.55 h60
  text "PTH" at 5222.08,865.55 h60
  text "Rectangle" at 5618.99,865.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,865.55 h60
  text "118.11mil (3.000mm)" at 7440.82,865.55 h60
  text "118.11mil (3.000mm)" at 8528.1,865.55 h60
  text "1" at 3693.79,715.55 h60
  text "39.37mil (1.000mm)" at 4234.26,715.55 h60
  text "PTH" at 5222.08,715.55 h60
  text "Rectangle" at 5618.99,715.55 h60
  text "Top Layer - Bottom Layer" at 6208.2,715.55 h60
  text "137.80mil (3.500mm)" at 7440.82,715.55 h60
  text "137.80mil (3.500mm)" at 8528.1,715.55 h60
  text "1273 Total" at 3693.79,565.55 h60
  text "Slot definitions :" at 3236.2,420.57 h60
  text "Routed Path Length" at 3971.63,420.57 h60
  text "= Calculated from tool start centre position to tool end centre position." at 4849.03,420.57 h60
  text "Hole Length" at 3971.63,320.59 h60
  text "= Routed Path Length + Tool Size = Slot length as defined in the PCB layout" at 4506.53,320.59 h60
  text "Drill tolerances:" at 6666,-128 h75
  text "FOR PTH +/- 3MIL" at 6712,-275 h75
  text "FOR NPTH +/- 2MIL" at 6707,-421 h75
  text "For 12.2 mil drill via +0/-12.2 mil" at 6715,-556 h75
  text "For 7.87 mil drill via +0/-7.87 mil" at 6715,-744 h75
  text ".Layer_Name" at -303,-1278.49 h60
M17 Embedded Cavity:
  text ".Layer_Name" at -303,-1278.49 h60
M18 Embedded Assembly:
  text ".Layer_Name" at -303,-1278.49 h60
M19 Embedded Keepout:
  text ".Layer_Name" at -303,-1278.49 h60