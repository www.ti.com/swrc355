# Altium PCB PROC074B-PCB.PcbDoc (part 5 of 9)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 2755.91 x 5300 mil, 10 copper layers (Top Layer, L2-GND, L3-SIG1, L4-GND, L5-PWR/SIG, L6-SIG2, L7-PWR2, L8-SIG3, L9-GND, Bottom Layer), stack 67.57 mil thick; 585 components, 490 nets, 2137 pads, 1150 vias.

## Via types
v1: diameter 22.4, hole 12.2, Top Layer to Bottom Layer, tented both sides, 1123 vias
v2: diameter 15.75, hole 7.87, Top Layer to Bottom Layer, tented both sides, 14 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 13 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
GND: C1.1 C2.1 C3.1 C4.2 C5.1 C6.1 C7.1 C8.1 C9.1 C10.1 C11.1 C12.1 C13.1 C14.1 C15.1 C16.1 C17.1 C18.1 C19.1 C20.1 C21.1 C22.2 C23.2 C24.1 C25.1 C26.1 C27.2 C28.2 C29.2 C30.2 C31.2 C32.1 C33.1 C34.1 C35.1 C36.1 C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.1 C44.1 C45.1 C46.1 C47.1 C48.1 C49.1 C50.2 C51.2 C52.1 C53.2 C54.1 C55.2 C56.2 C57.2 C58.2 C59.2 C60.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C67.2 C68.2 C69.2 C70.2 C71.2 C72.2 C73.2 C74.2 C75.2 C76.2 C77.2 C79.2 C80.2 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C87.2 C88.1 C89.2 C90.2 C91.2 C92.2 C93.2 C94.2 C95.2 C97.2 C98.2 C99.2 C100.2 C101.2 C102.2 C103.2 C104.2 C105.2 C106.2 C107.2 C108.2 C109.2 C110.2 C111.2 C112.2 C113.2 C114.2 C115.2 C116.2 C117.2 C120.1 D1.2 D4.2 D5.2 D6.2 D7.2 D8.2 D9.2 D10.2 D11.1 D14.1 DS4.2 J1.2 J2.2 J3.2 J3.3 J4.20 J4.26 J4.32 J4.38 J4.44 J4.50 J4.MP1 J4.MP2 J4.MP3 J4.MP4 J5.4 J6.2 J7.1 J7.2 J8.1 J8.2 J9.16 J9.57 J9.58 J9.MP1 J9.MP2 J9.MP3 J9.MP4 J10.18 J10.24 J10.30 J10.36 J10.42 J10.48 J10.54 J10.60 J10.MP1 J10.MP2 J10.MP3 J10.MP4 J12.5 J16.5 J17.19 J17.25 J17.28 J17.30 J17.31 J17.32 J17.37 J17.43 J17.56 J17.MP1 J17.MP2 J17.MP3 J17.MP4 J18.2 J18.5 J18.6 J18.9 J18.10 J18.13 J18.14 J19.4 J19.8 J19.10 J19.12 J20.3 J20.4 J20.9 J20.10 J20.15 J20.16 P2.2 P2.3 pad.6 pad.TH1 Q1.2 Q2.2 R5.2 R12.1 R16.1 R17.1 R41.1 R62.1 R63.1 R65.1 R66.1 R68.1 R69.1 R95.1 R111.1 R112.1 R126.1 R127.1 R130.1 R135.1 R139.1 R143.1 R149.1 R153.1 R155.1 R156.1 R163.2 R164.2 R170.1 R172.1 R201.1 R223.1 R225.2 R226.1 R227.1 R244.1 R246.1 R248.1 R261.1 R262.1 R308.1 R311.1 R318.1 R327.1 R330.1 R332.1 R338.1 R339.1 R364.1 R367.1 R369.1 R370.1 R397.1 R399.1 R400.1 R401.1 R402.1 R404.1 S1.1 S1.2 S1.3 S1.4 S1.5 S1.6 S1.7 S1.8 S1.9 S1.10 S1.11 S1.12 SW1.5 SW2.5 TP1.1 U1.2 U2.6 U3.2 U4.4 U4.11 U4.17 U4.24 U4.27 U5.6 U6.2 U7.3 U8.10 U8.17 U8.48 U8.55 U8.58 U8.64 U8.66 U8.80 U8.114 U9.2 U10.6 U11.7 U12.1 U12.7@1106.98,1680.06 U13.3 U13.5 U13.6 U13.7 U13.8 U13.10 U13.11 U13.12 U13.13 U13.20 U14.5 U15.1 U15.5 U15.10 U15.11 U15.13 U15.15 U15.25 U15.35 U15.47 U15.51 U16.3 U17.6 U17.9@1332.36,2705 U18.2 U19.2 U20.7 U21.7 U22.7 U23.7 U24.6 U25.6 U26.6 U27.6 U28.6 U29.3 U29.5 U29.6 U29.7 U29.8 U29.10 U29.11 U29.12 U29.13 U29.20 U30.6 U30.9 U31.2 U32.2 U33.6 U34.6 U35.6 U36.6 Y1.2 Y1.4 Y2.2 Y2.4 | length 16458.1
  Top Layer w7.8: U33.6@1503.83,2082.37 1528.05,2082.37 v1(1538.37,2072.06) 1550.31,2084 1578.31,2084 1585.08,2090.76 U19.2@1585.08,2113.82
  Top Layer w7.87: v1(1388,2253) 1393.87,2247.13 U28.6@1417.24,2247.13
  Top Layer w8: v1(464.37,859.06) 464.37,867.39 C109.2@501.21,904.23 ; v1(1170.75,840.43) R318.1@1204.37,840.43 ; v1(1379.37,929.06) 1388.03,937.72 U29.3@1410.73,937.72 ; v1(1470.37,2428.06) 1476.75,2421.68 U26.6@1499.49,2421.68 ; v1(1528.26,2566.95) 1534.7,2560.5 U25.6@1559.3,2560.5 ; v1(2360.57,4034.26) 2371.31,4045 R223.1@2406.38,4045
  Top Layer w9.8: C7.1@1642.37,2614.37 1659.38,2631.38 U20.7@1685.43,2631.38
  Top Layer w10: J9.16@143.57,1434.42 215.51,1434.42 v1(222.62,1441.53) ; v1(497.37,4477.06) 505.38,4469.05 J17.43@547,4469.05 ; v1(543.44,2881.3) 572.42,2852.32 J10.42@629.09,2852.32 ; v1(544.97,2781.73) 544.97,2761.08 571.84,2734.21 J10.54@629.09,2734.21 ; J17.19@547,4232.65 590.96,4232.65 v1(600.37,4242.06) ; J17.25@547,4291.75 v1@593.06,4291.75 ; J17.31@547,4350.85 v1@592.48,4350.85 ; J17.37@547,4409.95 v1@597.68,4409.95 ; v1(559.13,2804.5) 570.36,2793.26 J10.48@629.09,2793.26 ; v1(562,3004) 562,2982.58 574.16,2970.43 J10.30@629.09,2970.43 ; v1(566.88,2902.09) 576.16,2911.37 J10.36@629.09,2911.37 ; J10.60@629.09,2675.15 672.36,2675.15 v1@689.75,2657.76 ; J10.24@629.09,3029.48 571.84,3029.48 550,3051.33 v1(550,3088) 550.54,3088.54 J10.18@629.09,3088.54 ; v1@689.75,2655.66 v1(690.86,2655.66) ; v1(703.37,1240.88) 703.37,1219.06 707.43,1215 C88.1@712.73,1215 ; v1(723.37,4587.06) 723.56,4587.25 J17.56@790,4587.25 ; J17.28@790,4311.45 839.98,4311.45 v1(852.37,4299.06) ; J17.30@790,4331.15 927.46,4331.15 v1(931.37,4335.06) ; J17.32@790,4350.85 851.16,4350.85 v1(858.37,4358.06) ; C100.2@1194.37,1044.06 1231.81,1006.62 U29.13@1261.12,1006.62 ; C104.2@1325.75,819.06 1335.93,829.23 U29.20@1335.93,868.82 ; U17.6@1387.48,2692.2 1411.52,2692.2 v1(1436.37,2717.06) ; C86.2@1859.37,1177.68 1870.51,1166.54 1899.88,1166.54 1902.4,1169.06 U13.20@1922.56,1169.06 ; v1(1979.37,1129.06) 1991.46,1116.97 U13.3@1991.46,1094.25 ; v1(1989.63,4523) 1994.68,4528.05 J4.50@2081.5,4528.05 ; v1(2012.06,4350.75) J4.32@2081.5,4350.75 ; v1(2012.37,4313.06) 2026.37,4313.06 2047.78,4291.65 J4.26@2081.5,4291.65 J4.26@2081.91,4292.06 ; v1@2036.68,4468.95 J4.44@2081.5,4468.95 ; J4.38@2081.5,4409.85 2081.66,4410 v1(2126.63,4410) ; v1@2178.76,2899.06 R95.1@2210.68,2899.06
  Top Layer w10.9: J9.58@143.57,1847.8 143.83,1848.06 v1(203.37,1848.06) ; v1(298.37,1865.06) 298.37,1855.63 306.2,1847.8 J9.57@369.17,1847.8
  Top Layer w11.8: U15.47@1098.19,3144 1171,3144 v1(1181,3154) ; 1209.11,2996.37 1208.42,2997.06 U15.51@1208.42,3053.45 1208.42,3097.42 v1(1223,3112) ; v1(1481,3149) 1481,3144.9 1501.59,3124.32 U15.1@1535.19,3124.32
  Top Layer w12: U30.6@657.29,1317.79 699.62,1317.79 U30.9@712.41,1305
  Top Layer w15: R135.1@113.85,861.27 v1(113.85,885.29) ; J9.MP1@256.37,1264.54 v1(256.37,1330.79) ; J9.MP2@256.37,1457.06 v1(256.37,1565.28) ; J9.MP3@256.37,1707.06 v1(256.37,1815.28) ; J9.MP4@256.37,1899.58 v1(256.37,1965.28) ; R139.1@317.18,906.74 v1(317.18,934.95) ; C50.2@334.43,2247.48 334.43,2253.43 v1(371.67,2290.67) ; v1(355.96,792.83) R143.1@355.96,818.64 ; v1(467.37,2034.06) 538.36,2034.06 C112.2@550.37,2022.05 ; v1(469.37,3202.06) 505.94,3202.06 516.3,3191.7 J10.MP2@516.3,3085.59 J10.MP2@516.3,3010.7 ; C72.2@474.37,2178.3 v1@505.13,2178.3 ; v1@507.13,2178.3 v1@505.13,2178.3 ; v1@512.75,3393.79 v1(512.88,3393.92) ; v1@513.72,3392.81 516.3,3390.24 J10.MP1@516.3,3278.11 ; v1(516.3,2563.7) J10.MP4@516.3,2643.07 ; J10.MP3@516.3,2835.59 516.3,2959.3 v1(539.37,2982.38) ; v1(534.7,1047.45) U31.2@534.7,1084.42 ; R16.1@543.87,2178.68 536.24,2171.06 v1(512.37,2171.06) v1@505.13,2178.3 ; v1(554,53.33) DS4.2@554,89.57 ; v1@586.73,1293.95 v1(587.35,1293.32) ; v1@592.48,4350.85 v1(592.63,4351) ; v1@593.06,4291.75 v1(593.37,4292.06) ; v1@597.68,4409.95 v1(600.38,4407.25) ; C111.2@643.37,1646.56 669.37,1620.56 v1(669.37,1606.06) ; v1@645.37,1439.05 v1(646.37,1440.06) ; J17.MP1@668.5,4008.65 668.5,4089.19 v1(669.37,4090.06) ; J17.MP2@668.5,4216.15 669.37,4217.02 v1(669.37,4328.06) ; J17.MP3@668.5,4466.15 J17.MP3@668.5,4465.75 668.5,4359.13 v1(670.63,4357) ; J17.MP4@668.5,4673.65 J17.MP4@668.5,4673.25 668.5,4609.13 v1(670.63,4607) ; v1(673.37,1820.06) 676.37,1817.06 U32.2@676.37,1779.86 U32.2@676.37,1775.92 ; v1(693,53.33) D10.2@693,89.57 ; v1(700.37,2002.99) 725.14,2027.76 762.54,2027.76 C117.2@765.61,2024.68 ; R339.1@704.13,2219.06 704.13,2181.3 v1(704.37,2181.06) 704.75,2180.68 C94.2@704.75,2141.06 ; 722.85,1356.53 C120.1@722.85,1392.79 ; v1(760,57) 761,58 D5.2@761,89.57 ; C73.2@809.25,2482 809.25,2453.88 v1(819.01,2444.12) ; C27.2@813.62,2330 813.62,2358.97 822.99,2368.34 v1(846.51,2368.34) ; v1(829.94,57) D6.2@829.95,89.57 ; R41.1@834.37,2017.43 852.37,1999.43 v1(852.37,1984.06) ; D7.2@898.94,89.57 898.94,60.06 v1(899,60) ; v1(912,3244) C36.1@947.12,3243.99 ; v1(970,53.33) D8.2@970,89.57 ; v1(1055,2854) 1075.5,2854 C69.2@1100,2878.5 ; C77.2@1091,1765.53 v1(1091,1805.15) ; U15.35@1098.19,3380.22 v1(1154.22,3380.22) ; v1(1131.37,2909.87) 1156.55,2935.06 1197.78,2935.06 1212.78,2950.06 C70.2@1212.78,2969.18 1209.11,2972.86 1209.11,2996.37 ; v1(1134.37,1978.24) 1147.61,1965 S1.2@1200,1965 ; v1(1145.14,2365) S1.10@1200,2365 ; U12.1@1145.37,1654.47 v1(1170.56,1654.47) ; v1(1150.37,2695.06) 1150.37,2709.68 C62.2@1160.75,2720.06 ; v1(1155,2065) S1.4@1200,2065 ; C67.2@1162.78,3627.8 1162.78,3657.47 v1(1176.37,3671.06) ; v1(1190.62,1864.53) 1200,1873.91 S1.1@1200,1915 ; S1.3@1200,2015 1252.74,2015 v1(1256.74,2011) 1277.74,1990 C2.1@1285.32,1990 ; S1.5@1200,2115 1159.7,2115 1150.67,2124.03 v1(1150.67,2145.78) 1150.67,2154.88 1160.79,2165 S1.6@1200,2165 ; S1.7@1200,2215 1163.13,2215 1148.65,2229.48 v1(1148.65,2245.65) 1148.65,2256.87 1156.78,2265 S1.8@1200,2265 ; S1.9@1200,2315 v1(1245.9,2315) ; S1.11@1200,2415 1163.6,2415 1155,2423.6 v1(1155,2435.69) 1155,2455.49 1164.51,2465 S1.12@1200,2465 ; v1(1204.62,1668.53) 1213.88,1659.28 U3.2@1243.6,1659.28 ; C65.2@1230,2597.76 1266.81,2597.76 v1(1275.51,2589.06) ; v1(1248.37,2444.06) 1272.37,2468.06 R338.1@1286.75,2468.06 ; v1(1306.85,3418.15) U15.25@1306.85,3490.46 ; C68.2@1357.99,2966.18 1389.4,2934.77 1389.4,2874.03 v1(1391.37,2872.06) ; v1(1414.37,3720.06) 1428.07,3706.36 1428.07,3650.96 C66.2@1422.78,3645.68 ; v1(1459.66,1825.63) 1462.66,1822.63 U1.2@1514.28,1822.63 ; v1(1460,3294) 1486,3294 1493.48,3301.48 U15.10@1535.19,3301.48 ; v1(1475.17,3321.17) U15.11@1535.19,3321.17 1592.18,3321.17 C56.2@1607.78,3305.56 ; v1(1476.09,3399.91) U15.15@1535.19,3399.91 ; v1(1477,3359) 1478.54,3360.54 U15.13@1535.19,3360.54 ; v1(1480.06,3203.06) U15.5@1535.19,3203.06 ; C57.2@1520.31,2971.95 v1(1520.31,3020.64) ; R172.1@1565.39,1992.63 1597.77,1992.63 v1(1602,1988.4) 1607.89,1982.51 C49.1@1640.09,1982.51 ; v1(1572,2874) 1589.28,2891.28 Y2.4@1628.36,2891.28 ; C7.1@1642.37,2614.37 1642.37,2550.06 v1(1689.37,2503.06) ; v1(1653,3399) 1661.2,3390.8 1661.2,3354.55 C54.1@1659.85,3353.21 1701.98,3353.21 C53.2@1719.85,3371.08 ; C26.1@1689.22,1477.84 1697.84,1477.84 1715.15,1495.15 1797.91,1495.15 1817.37,1514.61 v1(1817.37,1515.06) ; Y2.2@1691.35,2977.89 1731.11,2977.89 v1(1735,2974) ; C55.2@1811.38,2790 1811.38,2821.06 1852.37,2862.06 v1(1894.37,2862.06) ; v1(1817,2890) 1828.62,2901.62 C61.2@1828.62,2924 ; v1(1936.37,2522.06) 1943.78,2529.47 R311.1@1943.78,2556.69 ; v1@1959.17,4354.06 v1(1960.37,4354.06) ; v1(1959.63,4607) 1960,4607.37 J4.MP4@1960,4673.25 ; J4.MP1@1960,4008.25 1960,3942.63 v1(1960.63,3942) ; J4.MP2@1960,4215.75 1960.63,4215.12 v1(1960.63,4107) ; v1@1960,4364.37 J4.MP3@1960,4465.75 ; R332.1@1997.24,1422.07 2012.36,1422.07 v1(2024.37,1410.06) ; v1(2028.18,4232.55) J4.20@2081.5,4232.55 ; v1(2036.63,4469) v1@2036.68,4468.95 ; C4.2@2201.38,1885 2201.38,1908.01 2217.83,1924.46 v1(2236.22,1924.46) ; 2249.37,59.06 2279.37,89.06 C22.2@2279.37,142.91 ; v1(2254.47,1696.69) 2254.83,1696.33 R308.1@2301.14,1696.33 ; v1@2311.43,2537 SW1.5@2340.9,2537 ; C3.1@2367.41,1612.3 2367.41,1578.02 v1(2382.37,1563.06) ; R261.1@2377.84,1822.46 v1(2410.22,1822.46) ; v1(2415,1771) 2437.35,1748.65 Q1.2@2458.13,1748.65 ; v1(2513.34,3463.95) 2524.9,3452.39 C42.1@2524.9,3432.34 ; Q2.2@2517.76,4437.6 2560.91,4437.6 v1(2561.37,4438.06) ; v1(2570,815) 2572.7,812.3 D11.1@2572.7,761.77 ; J3.2@2570,4586.93 2571.13,4588.06 v1(2626.37,4588.06) ; J3.3@2570,4703.07 v1(2633.37,4703.06) ; v1(2591.31,4307.73) D9.2@2591.31,4338.43 ; v1(2624.37,4227.06) 2625.11,4227.8 D4.2@2625.11,4265.06 ; D14.1@2644.37,761.77 2644.37,814.37 v1(2645,815)
  Top Layer w20: R246.1@551.88,1293.95 v1@586.73,1293.95 ; R397.1@645.37,1409.01 v1@645.37,1439.05 ; v1(850.8,3025) 850.8,3009 874.8,2985 C58.2@940,2985 ; v1(910,3041) 911,3040 C59.2@951.38,3040 ; C52.1@1688.62,3160 R201.1@1688.62,3210 v1(1756,3210) ; C51.2@1706.5,3105 1737.5,3136 v1(1771,3136) ; C60.2@1823.62,2978 v1@1860,2978 ; SW2.5@2588.9,1985 2588.9,1966.22 2605.12,1950 v1(2626,1950)
  Bottom Layer w7.8: U18.2@333.74,2098.53 333.74,2081.32 338.62,2076.44 360.56,2076.44 368,2069 v1(368,2055) ; U8.17@1098.19,3277.86 1145.14,3277.86 v1(1155,3268) ; v1(1495,3524) 1503.7,3532.7 U8.55@1503.7,3573.13 ; v1(1550.94,3519.06) U8.58@1550.94,3573.13 ; U8.64@1645.43,3573.13 1645.43,3539.57 1651,3534 v1(1667,3534) ; v1(2159.37,1644.06) 2159.37,1645.61 2186.13,1672.37 U11.7@2203.71,1672.37 ; U2.6@2229.28,1966.36 2229.28,1931.4 v1(2236.22,1924.46) ; C6.1@2295,1605 v1(2330,1605)
  Bottom Layer w7.87: v1(1346.62,1850.31) U34.6@1346.62,1888.06
  Bottom Layer w8: U10.6@504.5,2202.3 504.5,2178.93 v1(512.37,2171.06) ; v1(559.37,2319.07) U24.6@587.39,2319.07 ; U27.6@675.13,2174.18 697.5,2174.18 v1(704.37,2181.06) ; U8.10@1098.19,3167.62 1137.55,3167.62 1151.17,3154 v1(1181,3154) ; v1(1351.37,3406.06) 1350.37,3407.06 1350.37,3438.06 1393.46,3481.15 U8.48@1393.46,3573.13 ; U8.114@1377.71,2966.84 1377.71,2943.72 1379.47,2941.97 1379.47,2883.96 v1(1391.37,2872.06) ; v1(1647,3269) 1655.86,3277.86 U8.80@1704.49,3277.86 ; U8.66@1704.49,3498.33 1770.37,3498.33 C44.1@1770.49,3498.45 ; v1(2392,3322) 2410.32,3303.69 U7.3@2430.19,3303.69
  Bottom Layer w10: v1(523.26,2473.95) 525,2472.2 566.23,2472.2 569.3,2469.13 U5.6@594.39,2469.13 ; v1(592.63,4351) 592.63,4399.49 v1(600.38,4407.25) ; U36.6@671.13,1993.18 690.57,1993.18 v1(700.37,2002.99) ; U35.6@1042.24,1932.87 1074.25,1932.87 v1(1079.62,1927.5) ; R225.2@1400,2674.81 1436.37,2711.18 v1(1436.37,2717.06) ; U4.4@1784.85,2020.25 1801.57,2020.25 1810.37,2029.06 1858.61,2029.06 v3(1859.65,2030.1) ; v1(1817.37,1515.06) 1829.17,1503.26 1854.27,1503.26 1862.37,1495.15 U21.7@1911.06,1495.15 ; U22.7@1852.76,2631.38 1899.72,2631.38 C25.1@1904.09,2627.01 1929.32,2627.01 v1(1966.37,2664.06) ; U14.5@1855.85,2807.8 1895.12,2807.8 1904.37,2817.06 1904.37,2852.06 v1(1894.37,2862.06) ; 1859.37,1889.06 1859.65,1889.34 U4.24@1859.65,1969.47 ; 1859.37,2167.06 1859.65,2166.77 U4.11@1859.65,2090.73 ; v3(1893.9,2030.1) 1903.75,2039.94 U4.17@1934.46,2039.94 ; v1(2040.37,1925.06) 2040.95,1925.64 R399.1@2040.95,1953.8 ; v1(2040.37,2134.06) 2040.95,2133.47 R401.1@2040.95,2108.8 ; C17.1@2041.9,2038.46 2058.97,2038.46 v1(2069.37,2028.06) ; R112.1@2142.05,2108.06 2174.37,2108.06 v1(2175.37,2109.06) ; v1(2396,3930) 2413.81,3912.19 U16.3@2425.32,3912.19
  Bottom Layer w12: C47.1@1895,3045.31 1917.68,3045.31 v1(1926,3037) ; C19.1@2066.22,2249.15 2066.22,2276.5 v1(2066.89,2277.16)
  Bottom Layer w15: v1(534.7,1047.45) 544.65,1037.5 C31.2@569,1037.5 ; C110.2@588.32,980.09 598.3,970.12 598.3,959.77 617.37,940.7 v1(617.37,937.06) ; v1(787.39,2645.26) 793.51,2651.38 R149.1@820,2651.38 ; R17.1@807.25,2524 816.63,2524 v1(841.63,2549) ; v1(853.11,2720.38) 863.38,2730.65 U6.2@863.38,2767.86 ; v1(889.37,3109.06) 895.31,3115 C45.1@940.32,3115 ; v1(889.37,3147.06) 911.49,3147.06 C46.1@933.49,3169.06 ; v1(969.54,1618.91) 969.54,1645.73 C75.2@992.37,1668.56 ; v1(1059.92,1805.53) 1059.92,1781.62 C76.2@1075.63,1765.91 ; v1(1134.37,1978.24) 1145.55,1967.06 R65.1@1178.13,1967.06 ; R226.1@1161.13,2769.06 1182,2789.93 v1(1182,2804) 1182,2881.37 C38.1@1190.68,2890.06 ; v1(1204.62,1668.53) 1225.75,1647.4 C74.2@1246.81,1647.4 ; v1(1256.74,2011) 1257.75,2012.01 C115.2@1257.75,2054.06 ; v1(1272.37,3752.06) 1297.05,3727.37 C34.1@1297.05,3692.06 ; C33.1@1306.37,2859.37 1306.37,2835.06 v1(1338.37,2803.06) ; C41.1@1345.37,2859.37 1378.68,2859.37 v1(1391.37,2872.06) ; C95.2@1383.62,2220 1388,2224.38 v1(1388,2253) 1388,2280.62 R262.1@1383.62,2285 ; v1(1396.37,1699.28) R12.1@1434.54,1699.28 ; v1(1399.62,1512.53) 1411.03,1501.13 C71.2@1433.64,1501.13 ; v1(1414.37,3720.06) 1414.37,3714.96 C35.1@1435.49,3693.85 ; v1(1459.66,1825.63) 1459.66,1851.63 1468.35,1860.32 C1.1@1495,1860.32 R5.2@1530,1860.31 ; C114.2@1473.62,2057 1523.31,2057 v1(1538.37,2072.06) 1480.18,2130.24 R62.1@1479.21,2130.24 ; R170.1@1475.49,3693.45 v1(1475.49,3728.49) v1@1476,3729 ; C5.1@1536.81,1652.4 1538.37,1653.96 v1(1538.37,1692.06) ; v1(1572,2874) 1576.92,2869.08 C32.1@1615.49,2869.08 ; R164.2@1590.49,3693.45 v1(1590.49,3728.49) v1@1591,3729 ; v1(1602,1988.4) 1620.35,1970.06 R402.1@1674.68,1970.06 ; v1(1617.49,1401.46) 1619.29,1403.27 R327.1@1650.75,1403.27 ; R163.2@1625.49,3693.45 v1(1625.49,3728.49) v1@1626,3729 ; C20.1@1654.22,1817.46 1654.22,1793.31 v1(1658.08,1789.45) ; C18.1@1658.54,2230.06 1658.54,2260.23 1663.69,2265.38 v1(1664.37,2265.38) ; R400.1@1686.58,2113.8 1688.55,2111.83 1688.55,2086.79 v1(1688.22,2086.46) ; C43.1@1715.49,2904.08 1729.08,2904.08 v1(1744,2919) v1@1745,2919 ; C44.1@1770.49,3498.45 1799.55,3498.45 v1(1800,3498) ; v1(1771,3136) 1781.5,3125.5 Y1.4@1817.69,3125.5 ; C40.1@1775.49,3323.45 C39.1@1820.49,3323.45 1822.04,3325 v1(1849,3325) ; C48.1@1857.68,3246 1890,3246 v1(1892,3248) 1904.31,3235.69 Y1.2@1904.31,3200.5 ; v1(1889.25,1379.91) 1929.37,1339.79 R404.1@1929.37,1322.68 ; v1(2063.81,1791.76) 2068.22,1796.18 C21.1@2068.22,1819.77 ; v1(2089.37,2494.06) 2090.11,2493.32 J8.2@2090.11,2443 2169.31,2443 v1(2169.37,2443.06) ; v1(2173.37,2542.06) 2174.31,2543 J8.1@2230.07,2543 2230.07,2576.35 v1(2220.37,2586.06) ; v1(2325.37,2619.06) 2325.43,2619 R126.1@2359.32,2619 ; R130.1@2455,4440.31 2455,4407.43 v1(2456.37,4406.06) ; R227.1@2460.75,3832.06 2460.75,3862.43 v1(2461.37,3863.06) ; v1(2530.37,2018.06) 2530.43,2018 R127.1@2559,2018 ; v1(2542.37,3876.06) 2569.53,3903.21 J12.5@2592.69,3903.21 ; C24.1@2595.37,2018.37 2595.37,1980.63 v1(2626,1950)
  Bottom Layer w20: v1(81.62,1384.53) R244.1@120,1384.53 ; v1(235.37,2443.06) 235.43,2443 J7.2@307.63,2443 ; J7.1@447.59,2543 495.71,2543 v1@516.44,2563.73 ; J5.4@530.07,3543 589.43,3543 v1(627.37,3505.06) ; v1(617.37,937.06) 643.43,911 R367.1@670.76,911 ; v1(628.62,1012.53) 640.16,1001 R364.1@675.76,1001 ; v1(669.37,1606.06) 671.37,1608.06 R369.1@725.13,1608.06 ; v1(673.37,1820.06) 678.37,1815.06 C113.2@714.37,1815.06 ; v1(679.37,1545.06) 699.37,1525.06 R370.1@723.75,1525.06 ; U9.2@805.62,3064.76 839.14,3064.76 850.8,3053.1 v1(850.8,3025) 822.57,3025 807.1,3009.53 C30.2@807.1,2980.22 ; v1(819.01,2444.12) 831.88,2431.25 R63.1@831.88,2399.95 ; C116.2@826.13,1890.06 826.13,1843.3 v1(830.37,1839.06) 839.57,1829.86 867.64,1829.86 875.84,1838.06 R68.1@889.75,1838.06 ; C28.2@900.37,2635.3 900.37,2598.76 v1(917.07,2582.06) ; v1(910,3041) 910,2998.87 C29.2@912.37,2996.5 ; C37.1@1031.37,3091.37 1031.37,3088.63 v1(1050,3070) ; v1(1248.37,2444.06) 1274.37,2418.06 C93.2@1286.75,2418.06 ; v1(1275.51,2589.06) C64.2@1275.51,2627.57 ; R66.1@1543.55,2599.87 1528.26,2584.58 v1(1528.26,2566.95) 1543.66,2551.54 C92.2@1543.66,2533.13 ; v1(1576.86,2284.91) 1576.86,2319.6 R111.1@1581.72,2324.46 ; R330.1@1684.05,2527.06 1684.05,2508.37 v1(1689.37,2503.06) ; C8.1@2004.05,1514.06 2004.05,1430.37 v1(2024.37,1410.06) ; R248.1@2101.19,4390.15 2106.78,4390.15 v1(2126.63,4410) ; R69.1@2113.63,4141.99 v1(2154.64,4141.99) ; J6.2@2230.07,3643 2302.31,3643 v1(2308.37,3649.06) ; v1(2360.57,4034.26) 2360.89,4033.95 C63.2@2407.75,4033.95 ; v1(2493.82,3542.06) 2494.05,3541.82 R155.1@2494.05,3505.06 ; R156.1@2498.62,3117.56 2529.18,3087 v1(2537,3087) ; v1(2543.82,3544.52) 2544.37,3543.96 R153.1@2544.37,3505.28
  other v1: 2159.37,49.06 2005,70 1952,72 2159,85 2249.37,519.06 2284.27,519.06 2320,519 2364,569 2252.37,624.06 2178.37,712.06 1624.37,739.06 1729.37,739.06 2091.87,739.06 2178.37,746.95 2091.87,769.06 1624.37,774.06 1729.37,779.06 2178.37,781.85 1411.37,787.06 2091.87,799.06 1624.37,809.06 1729.37,814.06 2178.37,816.74 2091.87,829.06 2178.37,851.64 2351.37,852.06 2244.37,853.06 2282.37,853.06 2316.37,854.06 2091.87,859.06 2178.37,886.54 2091.87,889.06 2091.87,919.06 1796.37,997.06 1439.37,1009.06 924.37,1029.06 959.27,1029.06 994.16,1029.06 1029.06,1029.06 1063.95,1029.06 1098.85,1029.06 1796.37,1031.06 1439.37,1036.56 2064.37,1059.06 2091.87,1059.06 2119.37,1059.06 1439.37,1064.06 1798.37,1067.06 2124.37,1089.06 924.37,1124.06 959.27,1124.06 994.16,1124.06 1063.95,1124.06 1103.37,1124.06 1569.89,1129.06 1604.79,1129.06 1639.68,1129.06 1674.58,1129.06 1709.47,1129.06 1744.37,1129.06 1024.37,1188.06 2129.05,1237.34 1574.89,1239.06 1609.79,1239.06 1638.37,1239.06 1679.58,1239.06 1714.47,1239.06 1749.37,1239.06 2132.37,1271.06 2100.37,1272.06 1679.37,1278.06 1679.37,1319.06 2180.37,1319.06 1679.37,1349.06 2184.37,1355.06 2159.37,1381.06 2161.37,1419.06 2252.37,1419.06 1230.92,1427.83 1265.82,1427.83 1294.4,1427.83 1335.61,1427.83 1370.51,1427.83 2161.37,1454.06 2254.37,1457.06 1120,1472 2161.37,1481.06 2255.37,1489.06 2162.37,1509.06 2254.37,1522.06 2160.67,1543.78 1811.65,1782.46 1841.65,1782.46 1874.65,1782.46 1904.65,1782.46 1846.37,1878.06 1876.65,1879.46 1845.37,2181.06 1872.37,2182.06 1814.65,2277.72 1844.65,2277.72 1877.65,2277.72 1907.65,2277.72 2310.37,2538.06 1128.37,2808.06 2176.7,2901.11 1860.76,2978.76 2499.37,4024.06 1527.38,5123.25 849.75,5133.25 1053.38,5133.25 1249.38,5133.25 684.6,5141.25
  other v2: 1296.55,1034.18 1375.3,1034.18 2087.91,1129.69 2087.91,1208.43
  other v3: 712.41,1267.6 689.77,1305 735.05,1305 712.41,1342.4 1106.98,1658.4 1106.98,1701.71 1825.4,2030.1 1332.36,2667.6 1309.72,2705 1355,2705 1332.36,2742.4
HDR_PMIC_CLKOUT: J16.2 R347.2 | length 6136.2
  L8-SIG3 w4: J16.2@505,435 367.46,435 267.4,535.06 101.4,535.06 42.37,594.09 42.37,1799.51 277.5,2034.64 277.5,2232.5 33.37,2476.63 33.37,3941.17 831.25,4739.06 1369.37,4739.06 v1(1599.37,4509.06)
  Bottom Layer w6: v1(1599.37,4509.06) 1603.43,4505 R347.2@1668.01,4505
HDR_PMIC_EN: J16.4 R354.2 | length 5243.2
  L8-SIG3 w4: J16.4@605,435 544.94,495.06 324.37,495.06 272.37,547.06 106.37,547.06 54.37,599.06 54.37,1797.37 287.5,2030.5 287.5,2241.5 50.37,2478.63 50.37,3794.06 60.37,3804.06 60.37,3810.06 499.57,4249.26 499.57,4379.26 671.51,4551.2 819.12,4551.2 v1(846.98,4523.35)
  Bottom Layer w6: R354.2@813.62,4523.35 v1(846.98,4523.35)
HDR_SYNC_OUT_SOP1: J16.6 J16.10 R350.2 | length 5883
  Top Layer w6: R350.2@2455.01,4301.62 2486.69,4269.94 v1(2502.25,4269.94)
  L8-SIG3 w4: J16.6@705,435 765.06,495.06 848.37,495.06 905,438.43 J16.10@905,435 1000.5,530.5 1000.5,583.5 1022.48,605.48 1910.52,605.48 1937.93,578.07 2161.95,578.07 2418.94,835.06 2645.07,835.06 2675,864.99 2675,1657 2600,1732 2600,2006 2612,2018 2612,3041.32 2525.31,3128.01 2525.31,3353.55 2424.37,3454.49 2424.37,3646 2497,3718.63 2497,3883 2524,3910 2524,4248.19 v1(2502.25,4269.94)
I2C_SCL_SPIB_MISO_HDR: J16.3 U33.1 | length 2240.1
  Top Layer w6: U33.1@1432.97,2060.72 1432.97,2082.68 1438.35,2088.06 v1(1458.37,2088.06)
  L3-SIG1 w4: J16.3@605,335 655.29,385.29 655.29,469.46 712.52,526.69 712.52,671.77 762.75,722 813.24,722 876.9,785.66 876.9,1149.08 1023.37,1295.55 1023.37,1686.95 1098.73,1762.31 1191.58,1762.31 1367.87,1938.6 1367.87,1960.56 1458.37,2051.06 v1(1458.37,2088.06)
I2C_SDA_SPIB_MOSI_HDR: J16.7 U33.4 | length 2134.2
  Top Layer w6: U33.4@1480.21,2058.75 1480.21,2049.21 1519.37,2010.06 v1(1519.37,1985)
  L3-SIG1 w4: J16.7@805,335 756.13,383.87 756.13,476 799.04,518.91 799.04,683.27 888.59,772.82 888.59,1143.16 1238.66,1493.23 1238.66,1708.66 1288,1758 1343,1758 1445,1860 1488.78,1860 1519.37,1890.59 v1(1519.37,1985)
JTAG_TGT_DET: J9.15 R246.2 | length 223.7
  Top Layer w6: J9.15@369.17,1434.42 422.58,1434.42 455.62,1401.38 455.62,1370.16 473.62,1352.16 473.62,1314.96 R246.2@494.64,1293.95
JTAG_TRSTPD: J9.8 R244.2 | length 126.4
  Top Layer w6: J9.8@143.57,1355.68 200.77,1355.68 v1(212.62,1367.53)
  Bottom Layer w10: R244.2@167.25,1384.53 195.62,1384.53 v1(212.62,1367.53)
LOAD_SW_1: J27.2 R364.2 U31.3 | length 476.4
  Top Layer w10: U31.3@497.3,1084.42 497.3,1036.13 508.17,1025.25 606.42,1025.25 615.9,1034.73 781.27,1034.73 805,1011 J27.2@813,1011
  Bottom Layer w10: R364.2@723,1001 803,1001 J27.2@813,1011
LOAD_SW_2: J28.2 R369.2 U32.3 | length 388.6
  Top Layer w6: U32.3@713.77,1779.86 769.57,1779.86 819.37,1730.06 819.37,1642.06 857.37,1604.06 J28.2@869.37,1604.06
  Bottom Layer w15: R369.2@772.37,1608.06 875.37,1608.06 J28.2@879.37,1604.06
MCU_3V3: J5.1 J8.3 R122.1 | length 1232.4
  L3-SIG1 w30: v1(2165,2315) 2165,2368 2275,2478 2417,2478 2464,2525 2464,3083.15 2393.55,3153.6 v1(2381.9,3153.6)
  Bottom Layer w10: v1(238.37,3643.06) 238.43,3643 J5.1@307.63,3643
  Bottom Layer w20: v1(2165,2315) 2202.07,2315 J8.3@2230.07,2343
  other v1: 1849.37,3754.06 1889.37,3754.06 1069.37,3759.06 1114.37,3774.06 1119.37,3819.06
MCU_5V: C111.1 J5.2 J7.3 R50.1 R59.1 R113.1 R368.2 | length 484.6
  Top Layer w20: v1(605.37,1724.06) 628.87,1724.06 C111.1@643.37,1709.55
  Top Layer w30: v1(726.37,1736.06) 726.37,1694.61 R113.1@746.37,1674.61
  Bottom Layer w15: J7.3@447.59,2343 462.31,2343 477.66,2358.34 v1(477.66,2412.26) ; R50.1@519.37,1690.97 536.28,1690.97 569.37,1724.06 v1(605.37,1724.06) ; J5.2@530.07,3643 560,3643 591.06,3674.06 v1(606.37,3674.06) ; v1(614.37,3610.06) 620.37,3616.06 R59.1@665.82,3616.06 ; R368.2@724.75,1699.06 724.75,1734.43 v1(726.37,1736.06)
MCU_SOP0: R140.2 U27.7 | length 2190
  Top Layer w6: R140.2@434.59,915.14 434.59,932.55 v1(444.59,942.55)
  Bottom Layer w6: v1(444.59,942.55) 444.59,885.59 407,848 200,848 153.3,894.7 153.3,1017.7 28.68,1142.32 28.68,1502.68 60,1534 60,1768 215,1923 215,1962.24 238.24,1985.48 324.05,1985.48 352.29,2013.72 416.67,2013.72 457.37,2054.42 492.48,2054.42 498.81,2048.09 542.69,2048.09 587.46,2092.86 596.74,2092.86 652.02,2148.14 652.02,2181.08 660.87,2189.93 U27.7@675.13,2189.93
MCU_SOP1: R136.2 U27.5 | length 1761.9
  Top Layer w6: R136.2@234.85,861.27 v1(234.85,885.29)
  Bottom Layer w6: v1(234.85,885.29) 165.3,954.84 165.3,1032.2 40.68,1156.82 40.68,1486.68 76,1522 76,1751 229,1904 259.54,1904 357.26,2001.72 463.6,2001.72 494.98,2033.1 544.67,2033.1 592.43,2080.86 604.6,2080.86 647.95,2124.2 656.63,2124.2 675.13,2142.7 U27.5@675.13,2158.43
MCU_SOP2: R132.2 U27.2 | length 1961.1
  Top Layer w6: v1(114.85,800.45) R132.2@114.85,826.26
  L3-SIG1 w4: v1(114.85,800.45) 153.3,838.9 153.3,1067.05 206.25,1120 400,1120 455,1175 575.58,1175 652.61,1252.03 652.61,1343.73 778.37,1469.49 778.37,1837.06 812.57,1871.26 812.57,1890.42 765.37,1937.62 765.37,2018.59 742.91,2041.06 715.8,2041.06 694.86,2062 694.86,2079.11 710.8,2095.06 v1(745.37,2095.06)
  Bottom Layer w6: U27.2@730.24,2150.56 730.24,2122.01 745.37,2106.89 v1(745.37,2095.06)
MCUCLKOUT_HDR: J16.8 R359.2 | length 7280.4
  L8-SIG3 w4: J16.8@805,435 857,383 974,383 1083.4,492.4 1882.4,492.4 1958.07,568.07 2168.92,568.07 2371.85,771 2434,771 2458,747 2634,747 2687,800 2687,1662 2655,1694 2655,1941.43 2712.57,1999 2712.57,2965.86 2537.31,3141.12 2537.31,3355.69 2436.37,3456.63 2436.37,3637 2511,3711.63 2511,3878 2537,3904 2537,4285 2500.11,4321.89 2466.11,4321.89 2018.94,4769.06 1770.19,4769.06 1639.35,4638.22 1639.35,4594.85 1665,4569.2 1665,4520 1593.06,4448.06 v1(1569.37,4448.06)
  Bottom Layer w6: v1(1569.37,4448.06) 1571.43,4445.99 R359.2@1668.01,4445.99
MIPI60_JTAG_NTRST: J9.9 R243.1 | length 221.9
  Top Layer w6: J9.9@369.17,1375.36 427.79,1375.36 457.62,1345.53 457.62,1290.96 R243.1@504.64,1243.95
MIPI60_JTAG_TCK: J9.3 R236.1 R240.2 | length 4806.8
  Top Layer w6: v1(298.62,1324.53) 306.85,1316.31 J9.3@369.17,1316.31
  L6-SIG2 w4.5: v1(298.62,1324.53) 300.19,1324.53 359.17,1383.51 359.17,1878 293,1944.17 293,2430 110.17,2612.83 110.17,3482.86 150.37,3523.06 536.94,3523.06 673,3387 799,3387 941,3529 941,3841 1174.86,4074.86 1892.83,4074.86 v1(1920.23,4102.26)
  Bottom Layer w6: v1(1920.23,4102.26) 1926.63,4108.66 R240.2@1926.63,4139.38
  Bottom Layer w10: v1(298.62,1324.53) 306.85,1316.31 328.23,1316.31 R236.1@335.62,1308.91
MIPI60_JTAG_TDI: J9.5 R238.2 | length 142.7
  Top Layer w6: J9.5@369.17,1335.99 420.16,1335.99 v1(431.62,1324.53)
  Bottom Layer w10: R238.2@386.62,1364.15 416,1364.15 431.62,1348.53 v1(431.62,1324.53)
MIPI60_JTAG_TDO: J9.4 R239.2 | length 129.3
  Top Layer w6: J9.4@143.57,1316.31 201.69,1316.31 210.98,1307.02 v1(210.98,1293.53)
  Bottom Layer w10: R239.2@166.62,1286 200.55,1286 v1@208.08,1293.53
MIPI60_JTAG_TMS: J9.2 R237.2 | length 118.7
  Top Layer w6: v1(93.21,1259.33) 93.21,1284 105.83,1296.62 J9.2@143.57,1296.62
  Bottom Layer w10: v1(93.21,1259.33) 119,1233.53 R237.2@121,1233.53
MIPI60_MUX_IN: J9.51 R283.2 | length 4895.6
  Top Layer w6: J9.51@369.17,1788.75 422.75,1788.75 429.57,1795.57 429.57,1881.22 414.74,1896.06 349.97,1896.06 303.8,1942.23 303.8,2066.77 304.1,2067.07 304.1,2266.93 91.17,2479.86 91.17,3673.17 162,3744 670,3744 819.86,3893.86 1732.63,3893.86 1747.83,3909.06 2156,3909.06 2291.37,4044.43 v1(2291.37,4248.06)
  Bottom Layer w6: R283.2@2115.25,4351 2162.43,4351 2265.37,4248.06 v1(2291.37,4248.06)
MIPI60_RTCK: J9.7 R236.2 | length 97.1
  Top Layer w6: v1(305.62,1358.53) 308.48,1355.68 J9.7@369.17,1355.68
  Bottom Layer w10: v1(305.62,1358.53) 311.25,1364.15 R236.2@335.62,1364.15
MIPI60_TRACE_CTL: J9.17 R20.2 | length 196
  Top Layer w6: J9.17@369.17,1454.1 419.87,1454.1 471.62,1402.35 471.62,1376.96 R20.2@504.64,1343.95
MIPI60_TRACE_D0: J9.19 R21.2 | length 168.5
  Top Layer w6: J9.19@369.17,1473.79 424.8,1473.79 R21.2@504.64,1393.95
MIPI60_TRACE_D1: J9.21 R27.2 | length 156
  Top Layer w6: J9.21@369.17,1493.47 455.11,1493.47 R27.2@504.64,1443.95
MIPI60_TRACE_D2: J9.23 R28.2 | length 143.4
  Top Layer w6: J9.23@369.17,1513.16 485.43,1513.16 R28.2@504.64,1493.95
MIPI60_TRACE_D3: J9.25 R29.2 | length 142.1
  Top Layer w6: J9.25@369.17,1532.84 488.54,1532.84 R29.2@504.64,1548.95
MIPI60_TRACE_D4: J9.27 R30.2 | length 154.7
  Top Layer w6: J9.27@369.17,1552.53 458.22,1552.53 R30.2@504.64,1598.95
MIPI60_TRACE_D5: J9.29 R268.2 | length 167.3
  Top Layer w6: J9.29@369.17,1572.21 427.91,1572.21 R268.2@504.64,1648.95
MIPI60_TRACE_D6: J9.31 R269.2 | length 200.8
  Top Layer w6: J9.31@369.17,1591.9 424.9,1591.9 465.18,1632.18 465.18,1664.49 R269.2@504.64,1703.95
MIPI60_TRACE_D7: J9.33 R270.2 | length 232
  Top Layer w6: J9.33@369.17,1611.58 426.41,1611.58 453.18,1638.36 453.18,1669.46 479,1695.28 479,1728.31 R270.2@504.64,1753.95
MIPI60_TRACE_D8: J9.35 R54.2 | length 259.9
  Top Layer w6: J9.35@369.17,1631.27 422.27,1631.27 441.18,1650.18 441.18,1674.43 466,1699.25 466,1765.31 R54.2@504.64,1803.95
MIPI60_TRACE_D9: J9.37 R96.2 | length 138.9
  Top Layer w6: v1(297.37,1629.7) 318.62,1650.95 J9.37@369.17,1650.95
  Bottom Layer w10: v1(297.37,1629.7) 337.54,1589.53 R96.2@339,1589.53
MIPI60_TRACE_D10: J9.39 R144.2 | length 266.1
  Top Layer w6: J9.39@369.17,1670.64 413.8,1670.64 450,1706.84 450,1769 475,1794 475,1826.62 R144.2@503.38,1855
MIPI60_TRACE_D11: J9.41 R145.2 | length 150.1
  Top Layer w6: v1(289.37,1674.06) 305.64,1690.32 J9.41@369.17,1690.32
  Bottom Layer w10: v1(289.37,1674.06) 303.43,1660 319.53,1660 R145.2@339,1640.53
MIPI60_TRACE_D12: J9.43 R146.2 | length 138.4
  Top Layer w6: v1(289.37,1710.06) 369.12,1710.06 J9.43@369.17,1710.01
  Bottom Layer w10: v1(289.37,1710.06) 307.89,1691.53 R146.2@340.25,1691.53
MIPI60_TRACE_D13: J9.45 R229.2 | length 259.2
  Top Layer w6: J9.45@369.17,1729.69 417.78,1729.69 435,1746.91 435,1775 457.62,1797.62 457.62,1846.31 470.37,1859.06 470.37,1870.49 481.57,1881.69 481.57,1882.1 R229.2@504,1904.53
MIPI60_TRACE_D14: J9.47 R230.2 | length 103.3
  Top Layer w6: v1(304.37,1744.06) 309.69,1749.38 J9.47@369.17,1749.38
  Bottom Layer w10: v1(304.37,1744.06) 305.89,1742.53 R230.2@340,1742.53
MIPI60_TRACE_D15: J9.49 R231.2 | length 135.6
  Top Layer w6: v1(292.37,1777.06) 300.36,1769.06 J9.49@369.17,1769.06
  Bottom Layer w10: v1(292.37,1777.06) 308.85,1793.53 R231.2@341,1793.53
MUX1_MISO2: U34.2 U35.16 | length 569.3
  L5-PWR/SIG w4.5: v1(947.76,1970.83) 1040.15,1878.43 1111.63,1878.43 1161.49,1928.29 1385.12,1928.29 v1(1400,1943.17)
  Bottom Layer w6: U35.16@947.76,1948.62 v1(947.76,1970.83) ; U34.2@1370.24,1943.17 v1(1400,1943.17)
MUX1_RS232RX: U5.10 U28.4 | length 1542.6
  Top Layer w6: U28.4@1393.62,2223.5 1393.62,2186.8 v1(1396.37,2184.06)
  L6-SIG2 w4.5: v1(612.77,2611) 593.81,2611 550.19,2567.38 550.19,2504.19 542,2496 509.31,2496 497.37,2484.06 497.86,2483.57 497.86,2414.14 512.94,2399.06 563.13,2399.06 584.95,2377.23 605.8,2377.23 643.59,2339.44 872.64,2339.44 926.82,2285.26 1142.38,2285.26 1185.77,2241.87 1303.57,2241.87 1338.76,2277.06 1399.32,2277.06 1409,2267.38 1409,2230.27 1396.37,2217.64 v1(1396.37,2184.06)
  Bottom Layer w6: v1(612.77,2611) 627.25,2611 655,2583.25 655,2545.24 633.76,2524 U5.10@633.76,2508.5
MUX1_RS232TX: U5.7 U28.1 | length 1296.1
  Top Layer w6: U28.1@1346.38,2225.47 1346.38,2245.69 v1(1354.63,2253.94)
  L6-SIG2 w4.5: v1(522.63,2519) 487.31,2519 457.46,2489.14 457.46,2394.4 512.59,2339.27 570,2339.27 605.46,2303.81 632.92,2303.81 657.17,2328.06 853.06,2328.06 964.16,2216.96 1268.63,2216.96 1277.69,2226.02 1326.71,2226.02 v1(1354.63,2253.94)
  Bottom Layer w6: v1(522.63,2519) 555.43,2486.2 593.06,2486.2 U5.7@594.39,2484.87
MUX2_MOSI2: U34.5 U35.3 | length 772.3
  Bottom Layer w6: U35.3@1002.87,1956.5 1002.87,1991.87 1018.05,2007.04 1018.05,2046.41 1026.64,2055 1073.6,2055 1106,2022.6 1106,1918 1265,1759 1363.46,1759 1380,1775.54 1380,1845.33 1362.37,1862.96 U34.5@1362.37,1888.06
MUX_CLK2: U33.7 U34.8 | length 706.9
  Top Layer w6: U33.7@1503.83,2098.12 1528.28,2098.12 1533.37,2103.2 v1(1533.37,2120.06)
  L6-SIG2 w4.5: v1(1226.38,1829) 1317.92,1920.54 1408.39,1920.54 1431.03,1943.17 1512.06,1943.17 1565.37,1996.49 1565.37,2088.06 v1(1533.37,2120.06)
  Bottom Layer w6: v1(1226.38,1829) 1242.94,1829 1302,1888.06 U34.8@1315.13,1888.06
MUX_CS1: U10.11 U24.10 | length 2817.8
  Top Layer w6: v1(628.37,2155.06) 628.37,2126.45 635.56,2119.26 651.17,2119.26 660,2128.09 660,2289.14 680.01,2309.15 755.13,2309.15 789.95,2274.32 850.01,2274.32 865.57,2289.89 990.32,2289.89 1000.44,2279.77 1000.44,2224.32 990.98,2214.86 954.34,2214.86 946.85,2207.37 946.85,2189.52 955.31,2181.06 982.36,2181.06 994.3,2169.12 994.3,2104.36 1018.16,2080.5 1110.5,2080.5 1120.24,2090.24 1120.24,2115.29 1111.53,2124 1099.24,2124 1099.19,2123.95 1061.04,2123.95 1048.74,2136.25 1048.74,2168.19 1057.8,2177.25 1127.07,2177.25 1133.98,2184.16 1133.98,2211.13 1127.94,2217.17 1045.46,2217.17 1035.9,2226.73 1035.9,2273.78 1046.86,2284.74 1133.81,2284.74 1142.43,2293.36 1142.43,2310.85 1134.6,2318.68 1102.66,2318.68 1098.22,2323.12 1098.22,2478.19 1088.82,2487.59 1062.17,2487.59 1052,2477.42 1052,2323 1040,2311 1015.13,2311 1006.65,2319.48 1006.65,2424.43 1020.49,2438.27 1020.49,2481.95 981.25,2521.19 902.49,2521.19 855,2473.7 855,2418.14 832.86,2396 672,2396 653.94,2414.06 v1(628.82,2414.06)
  Bottom Layer w6: U10.11@543.87,2147.18 585.68,2147.18 589,2143.86 617.17,2143.86 v1(628.37,2155.06) ; U24.10@626.76,2358.44 626.76,2412 v1(628.82,2414.06)
MUX_CS2: U33.10 U34.11 | length 570.6
  Top Layer w6: U33.10@1464.46,2121.74 1465.17,2122.44 1465.17,2165.89 1469.77,2170.49 1469.77,2186.43 v1(1489.37,2206.03)
  L8-SIG3 w4: v1(1336.37,1953.06) 1369.63,1919.79 1471.61,1919.79 1489.57,1937.75 1489.57,2205.83 v1(1489.37,2206.03)
  Bottom Layer w6: U34.11@1307.25,1943.17 1326.49,1943.17 v1(1336.37,1953.06)
MUX_HOSTINTR1: U5.1 U25.2 | length 1049.2
  Top Layer w6: v1(1485.37,2496.06) 1504.18,2514.87 U25.2@1504.18,2536.88
  L6-SIG2 w4.5: v1(690.26,2429.95) 719.03,2458.72 767.07,2458.72 805.57,2420.22 862.22,2420.22 947.43,2335 1344.88,2335 1402.17,2392.29 1402.17,2444.39 1429.13,2471.36 1476.44,2471.36 1485.37,2480.29 v1(1485.37,2496.06)
  Bottom Layer w6: U5.1@665.25,2447.47 665.25,2441.44 678.76,2441.44 v1(690.26,2429.95)
MUX_IN_1: R25.1 S1.19 U10.15 | length 509.2
  Top Layer w6: v1(514.37,2069.06) 526.93,2056.5 573.8,2056.5 602.47,2085.18 638.47,2085.18 672.86,2119.56 769.44,2119.56 792,2097 809.94,2097 822.17,2109.23 822.17,2127.2 837.37,2142.4 R25.1@837.37,2144.69 857.68,2165 S1.19@900,2165
  Bottom Layer w6: U10.15@504.5,2107.81 504.5,2078.93 v1(514.37,2069.06)
MUX_IN_2: R26.1 S1.18 U5.15 | length 546.3
  Top Layer w6: v1(857.68,2252) 857.68,2246.97 889.66,2215 S1.18@900,2215
  L8-SIG3 w4: v1(851.81,2506.92) 867,2491.73 867,2386 891.76,2361.24 891.76,2286.08 v1(857.68,2252)
  Bottom Layer w6: U5.15@688.87,2469.13 724.5,2469.13 730.68,2462.95 797.57,2462.95 804.31,2469.69 R26.1@804.31,2482 842.53,2482 851.81,2491.28 v1(851.81,2506.92)
MUX_IN_3: R209.1 S1.15 U26.15 | length 580.7
  Top Layer w6: S1.15@900,2365 963.08,2365 v1(976.37,2378.29) ; v1(1257.68,2369.27) 1266.9,2360.06 1309.37,2360.06 1330.05,2380.74 R209.1@1330.05,2418.06 1333.68,2421.68 U26.15@1405,2421.68
  Bottom Layer w6: v1(976.37,2378.29) 994.78,2396.7 1230.25,2396.7 v1(1257.68,2369.27)
MUX_IN_4: R250.1 S1.14 U27.15 | length 518.9
  Top Layer w6: S1.14@900,2415 v1(959,2415)
  L5-PWR/SIG w4.5: v1(842.37,2115.06) 908.17,2180.86 908.17,2303.52 945.91,2341.26 945.91,2383.51 959,2396.6 v1(959,2415)
  Bottom Layer w6: U27.15@769.61,2174.18 807.87,2174.18 R250.1@837.37,2144.69 837.37,2120.06 v1(842.37,2115.06)
MUX_IN_5: R24.1 S1.20 U28.15 | length 498.1
  Top Layer w6: S1.20@900,2115 960.78,2115 v1(966.55,2109.23) ; v1(1253.53,2179.9) 1253.53,2206.85 R24.1@1267,2220.31 1293.81,2247.13 U28.15@1322.76,2247.13
  L5-PWR/SIG w4.5: v1(966.55,2109.23) 976.37,2119.04 1192.67,2119.04 v1(1253.53,2179.9)
MUX_IN_6: R151.1 S1.17 U25.15 | length 744
  Top Layer w6: S1.17@900,2265 v1(951,2265) ; v1(1245.37,2523.06) 1262.37,2523.06 1326.37,2587.06 1402.11,2587.06 R151.1@1426.03,2563.13 1428.66,2560.5 U25.15@1464.81,2560.5
  L5-PWR/SIG w4.5: v1(951,2265) 1073.74,2387.74 1169.51,2387.74 1203,2421.23 1203,2480.69 v1(1245.37,2523.06)
MUX_IN_7: R203.1 S1.16 U24.15 | length 289.6
  Top Layer w6: v1(841.98,2295) 861.98,2315 S1.16@900,2315
  Bottom Layer w6: U24.15@681.87,2319.07 798.82,2319.07 822.89,2295 v1(841.98,2295) 841.98,2327.7 R203.1@829.68,2340 R203.1@826.61,2340
MUX_IN_8: R18.1 S1.23 U33.15 | length 645
  Top Layer w6: S1.23@900,1965 909.13,1965 927.89,1946.24 1001.24,1946.24 1090,2035 v1(1142,2035) ; v1(1247.58,2138.77) 1283.03,2138.77 R18.1@1285.32,2141.06 1312.94,2113.43 1312.94,2103.05 1333.62,2082.37 U33.15@1409.35,2082.37
  L8-SIG3 w4: v1(1142,2035) 1172.47,2035 1247.58,2110.11 v1(1247.58,2138.77)
MUX_IN_9: R19.1 S1.22 U34.15 | length 623.7
  Top Layer w6: S1.22@900,2015 940,2015 988,2063 1118.19,2063 1143.59,2088.4 1228.44,2088.4 1261.84,2055 R19.1@1279.04,2055 1279.04,2087.73 v1(1289.37,2098.06)
  Bottom Layer w6: v1(1289.37,2098.06) 1312.94,2098.06 1330.1,2080.9 1330.1,2037.5 1346.62,2020.97 U34.15@1346.62,1982.54
MUX_IN_10: R23.1 S1.21 U35.15 | length 272.2
  Top Layer w6: S1.21@900,2065 947.51,2065 v1(955.31,2072.81)
  Bottom Layer w6: U35.15@947.76,1932.87 904.91,1932.87 R23.1@892.79,1945 892.79,1987.7 955.31,2050.22 v1(955.31,2072.81)
MUX_IN_11: R260.1 S1.24 U2.15 | length 1616.4
  Top Layer w6: S1.24@900,1915 1012,1915 1084,1843 1190,1843 1204,1829 1204,1788.38 1254.38,1738 1533.98,1738 1581.77,1690.21 1761.16,1690.21 1800.72,1729.77 2072.14,1729.77 2127.42,1785.05 R260.1@2212.06,1785.05 2212.06,1761.75 v1(2209.37,1759.06)
  Bottom Layer w6: v1(2209.37,1759.06) 2209.37,1799.14 2229.28,1819.06 U2.15@2229.28,1871.87
MUX_IN_12: R37.1 S1.13 U36.15 | length 780.6
  Top Layer w6: S1.13@900,2465 v1(987.6,2465)
  L5-PWR/SIG w4.5: v1(958.69,2145.64) 923,2181.33 923,2289 1016,2382 1016,2436.6 v1(987.6,2465)
  Bottom Layer w6: U36.15@765.61,1993.18 808.69,1993.18 832.96,2017.45 R37.1@832.96,2023.43 876.83,2023.43 891.43,2038.03 891.43,2121.43 915.64,2145.64 v1(958.69,2145.64)
MUX_MISO1: U10.8 U24.7 | length 2833.9
  Top Layer w6: v1(529.37,2369.06) 544.57,2353.86 620.54,2353.86 636.6,2337.8 636.6,2321.06 621,2305.47 582.97,2305.47 574.7,2297.2 574.7,2274.6 578.7,2270.6 600.8,2270.6 608.7,2262.7 608.7,2240.7 600.26,2232.26 575.46,2232.26 545.63,2202.43 492.74,2202.43 435.2,2259.97 435.2,2292.2 453.82,2310.82 453.82,2329.18 445,2338 432.63,2338 417.83,2323.2 401.8,2323.2 394,2331 394,2343.38 424.8,2374.17 424.8,2383.83 411.62,2397 402.17,2397 361.17,2356 341.06,2356 335,2362.06 335,2377 421.46,2463.46 421.46,2474.54 410.09,2485.91 399.91,2485.91 300,2386 289.06,2386 275.17,2399.89 275.17,2409.85 365,2499.68 365,2512 353.94,2523.06 339.35,2523.06 271.29,2455 256,2455 248,2463 248,2478 282,2512 282,2522 265,2539 255,2539 183,2467 168.1,2467 158.57,2476.53 158.57,2487.19 226.51,2555.13 226.51,2568.11 214.62,2580 199,2580 152,2533 137.31,2533 130,2540.31 130,2561 194,2625 224.02,2625 305.33,2543.69 390.51,2543.69 445.46,2488.74 445.46,2398.92 479.17,2365.21 479.17,2264.26 510.63,2232.8 527.37,2232.8 541.57,2247 v1(549,2247)
  Bottom Layer w6: v1(529.37,2369.06) 546.43,2352 555.01,2352 572.19,2334.82 U24.7@587.39,2334.82 ; U10.8@535.99,2202.3 535.99,2218.86 549,2231.86 v1(549,2247)
MUX_MISO2: U33.2 U34.1 | length 200.9
  Top Layer w6: U33.2@1448.72,2058.75 1448.72,1988.65 v1(1462.37,1975)
  Bottom Layer w6: U34.1@1368.28,1958.92 1386.92,1958.92 1416,1988 1449.37,1988 v1(1462.37,1975)
MUX_MOSI1: U10.4 U24.5 | length 2815.1
  Top Layer w6: v1(415,2247) 423,2247 450,2220 450,2123 440.82,2113.82 403.62,2113.82 396.4,2106.6 396.4,2088.4 383.2,2075.2 344.7,2075.2 331,2088.9 331,2151.91 345.09,2166 370.2,2166 381.2,2177 381.2,2254.2 391.87,2264.87 391.87,2299.04 367.71,2323.2 285.97,2323.2 267.72,2341.45 267.72,2375.28 255.94,2387.06 220.94,2387.06 208,2400 208,2436.98 197.14,2447.84 166.16,2447.84 115.17,2498.83 115.17,2607 131.17,2623 163.9,2623 176.6,2635.7 176.6,2651.5 165.1,2663 126.17,2663 115.17,2674 115.17,2772.9 124,2781.73 141.67,2781.73 150,2790.06 150,2814 141,2823 122,2823 115.17,2829.83 115.17,2862 137,2883.83 137,2911 115.17,2932.83 115.17,3010.17 128,3023 161,3023 172.43,3011.57 172.43,2696.52 307.32,2561.62 400,2561.62 457.62,2504 457.46,2503.84 482.5,2478.79 482.5,2455.8 457.46,2430.76 457.46,2403.89 492.42,2368.92 492.42,2317.78 500.94,2309.26 519.57,2309.26 v1(529.37,2319.06)
  Bottom Layer w6: v1(415,2247) 429,2247 461,2215 461,2189.37 471.69,2178.68 U10.4@480.87,2178.68 ; v1(529.37,2319.06) 552.43,2296 564.87,2296 572.19,2303.32 U24.5@587.39,2303.32
MUX_MOSI2: U33.5 U34.4 | length 284.2
  Top Layer w6: U33.5@1503.83,2066.62 1503.83,2056.59 1526.37,2034.06 v1(1534.37,2034.06)
  Bottom Layer w6: U34.4@1370.24,1911.68 1380.32,1911.68 1389,1903 1424.37,1903 1489.57,1968.2 1489.57,1989.26 v1(1534.37,2034.06)
MUX_NRST: U5.4 U25.5 | length 1454.4
  Top Layer w6: U25.5@1559.3,2544.76 1581.67,2544.76 v1(1593.37,2533.06)
  L6-SIG2 w4.5: v1(525.26,2426.95) 552.21,2426.95 589.92,2389.23 612.43,2389.23 650.85,2350.81 775.03,2350.81 815.44,2391.22 857.28,2391.22 950.66,2297.84 1148.78,2297.84 1193.19,2253.43 1298.64,2253.43 1442.8,2397.59 1442.8,2398.06 1485.91,2398.06 1532.17,2444.32 1532.17,2487.86 1577.37,2533.06 v1(1593.37,2533.06)
  Bottom Layer w6: v1(525.26,2426.95) 566.26,2426.95 574.37,2435.06 607.56,2435.06 U5.4@618.01,2445.5
MUX_RS232RX: U5.11 U25.10 | length 1081.2
  Top Layer w6: U25.10@1519.93,2599.87 v1(1519.93,2658.5)
  L6-SIG2 w4.5: v1(701.37,2587.06) 701.43,2587 856,2587 922.95,2520.05 1141.27,2520.05 1178.77,2557.55 1322.3,2557.55 1350,2585.26 1424.17,2585.26 1427.57,2581.86 1457.17,2581.86 1519.93,2644.62 v1(1519.93,2658.5)
  Bottom Layer w6: U5.11@649.5,2508.5 649.5,2521.39 674.86,2546.75 674.86,2574.06 687.86,2587.06 v1(701.37,2587.06)
MUX_RS232TX: U5.8 U25.7 | length 1531.2
  Top Layer w6: U25.7@1559.3,2576.25 1584.57,2576.25 1593.37,2585.06 1593.37,2614.06 v1(1574.37,2633.06)
  L6-SIG2 w4.5: v1(548.76,2672.66) 615.77,2672.66 676,2612.43 676,2544.92 694.72,2526.2 736.28,2526.2 783.08,2573 850,2573 916.63,2506.37 1147.22,2506.37 1186.64,2545.79 1334.4,2545.79 1339.99,2540.2 1377.51,2540.2 1404.37,2567.06 1463.37,2567.06 1529.37,2633.06 v1(1574.37,2633.06)
  Bottom Layer w6: v1(548.76,2672.66) 548.76,2517.66 565.8,2500.62 U5.8@594.39,2500.62
MUX_SCL_SPIB_MISO: J14.1 U35.2 | length 2772.9
  L5-PWR/SIG w4.5: v1(992.89,2020.97) 992.89,1950.02 1051.06,1891.86 1107.94,1891.86 1201.67,1985.59 1385.36,1985.59 1495.83,2096.06 1571.37,2096.06 1637.65,2162.34 1637.65,2303.77 1625,2316.42 1625,2350.08 1656.34,2381.42 1656.34,2416.21 1626.91,2445.64 1606.79,2445.64 1556,2496.43 1556,2518.15 1567.88,2530.02 1567.88,2601.31 1554.17,2615.01 1554.17,2644.86 1592.17,2682.86 1691.94,2682.86 1707.77,2698.69 1707.77,2753.66 1637.17,2824.26 1637.17,2952.17 1684.55,2999.55 1776.67,2999.55 1819.22,2957 1876,2957 1993.06,3074.06 J14.1@2382.37,3074.06
  Bottom Layer w6: U35.2@987.13,1956.5 987.13,2015.21 v1(992.89,2020.97)
MUX_SDA_SPIB_MOSI: J15.1 U35.5 | length 2496.6
  L5-PWR/SIG w4.5: v1(1080.17,1967.06) 1080.17,2066.88 1103.26,2089.97 1237.73,2089.97 1249.84,2077.86 1399.9,2077.86 1466.43,2144.39 1594.4,2144.39 1625,2174.99 1625,2294.63 1607.79,2311.84 1607.79,2421.19 1585.44,2443.54 1550.32,2443.54 1532.17,2461.69 1532.17,2516.17 1554.95,2538.95 1554.95,2588.64 1542.17,2601.42 1542.17,2652.17 1560.17,2670.17 1560.17,2721 1568.57,2729.4 1568.57,2776.91 1556.13,2789.35 1556.13,2827.41 1553.74,2829.8 ; 1527.8,2855.69 1553.69,2829.8 ; 1527.8,2855.74 1423.67,2959.87 1423.67,3129.26 1403.17,3149.76 1403.17,3177.42 1449.8,3224.06 1506.78,3224.06 1733.78,3451.06 1831.37,3451.06 J15.1@1869.37,3489.06
  Bottom Layer w6: U35.5@1042.24,1948.62 U35.5@1043.94,1948.62 ; U35.5@1043.49,1948.17 U35.5@1043.94,1948.62 ; v1(1080.17,1967.06) 1061.74,1948.62 U35.5@1043.94,1948.62
MUX_SPI_CLK1: U10.1 U24.2 | length 2849.5
  Top Layer w6: v1(429.57,2090.34) 431.8,2088.12 431.8,2025.1 416.3,2009.6 371.8,2009.6 356.2,2025.2 356.2,2034.37 316.1,2074.47 316.1,2271.9 103.17,2484.83 103.17,3045.42 123,3065.26 160.74,3065.26 189.75,3036.25 189.75,2982.25 190,2982 190,2705.92 312.92,2583 401.31,2583 503.06,2481.25 503.06,2420.58 516.89,2406.75 523.51,2406.75 536,2394.26 567.74,2394.26 590.97,2371.03 674.68,2371.03 681.65,2378 705.31,2378 720.05,2363.26 720.05,2339.42 709.17,2328.54 668.85,2328.54 640,2299.69 640,2233 619.06,2212.06 v1(595.37,2212.06)
  Bottom Layer w6: v1(429.57,2090.34) 429.57,2100.12 460.88,2131.43 U10.1@482.84,2131.43 ; v1(595.37,2212.06) 642.5,2259.19 U24.2@642.5,2295.45
NetC1_2: C1.2 R3.1 U1.3 | length 174.3
  Top Layer w20: v1(1457,1886) 1470.37,1872.63 U1.3@1514.28,1872.63 1557.91,1872.63 R3.1@1575,1855.54
  Bottom Layer w20: v1(1457,1886) 1470.69,1899.69 C1.2@1495,1899.69
NetC3_2: C3.2 R2.1 R7.2 | length 151
  Top Layer w6: C3.2@2406.78,1612.3 2426.17,1592.91 v1(2426.17,1589.06)
  Bottom Layer w8: R2.1@2388.32,1485 R7.2@2388.31,1525 2403.57,1540.26 2403.57,1566.46 v1(2426.17,1589.06)
NetC5_2: C5.2 R11.1 R31.2 | length 107.5
  Bottom Layer w12: R11.1@1481.79,1649.28 R31.2@1481.79,1599.28 1530.93,1599.28 C5.2@1536.81,1605.16
NetC18_2: C18.2 R101.1 | length 34.4
  Bottom Layer w6: C18.2@1658.54,2190.69 1692.19,2190.69 R101.1@1692.69,2191.19
NetC19_2: C19.2 R102.1 | length 34
  Bottom Layer w15: R102.1@2032.22,2209.78 C19.2@2066.22,2209.78
NetC20_2: C20.2 R103.1 | length 35.3
  Bottom Layer w15: C20.2@1654.22,1856.83 1688.54,1856.83 R103.1@1689.22,1856.15
NetC21_2: C21.2 R104.1 | length 34
  Bottom Layer w6: R104.1@2034.22,1859.14 C21.2@2068.22,1859.14