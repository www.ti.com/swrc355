# Altium PCB PROC074B-PCB.PcbDoc (part 6 of 9)
Units mil, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 2755.91 x 5300 mil, 10 copper layers (Top Layer, L2-GND, L3-SIG1, L4-GND, L5-PWR/SIG, L6-SIG2, L7-PWR2, L8-SIG3, L9-GND, Bottom Layer), stack 67.57 mil thick; 585 components, 490 nets, 2137 pads, 1150 vias.

## Via types
v1: diameter 22.4, hole 12.2, Top Layer to Bottom Layer, tented both sides, 1123 vias
v2: diameter 15.75, hole 7.87, Top Layer to Bottom Layer, tented both sides, 14 vias
v3: diameter 19.68, hole 7.87, Top Layer to Bottom Layer, tented both sides, 13 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
NetC22_1: C22.1 C23.1 FB1.2 FB2.2 P3.2 P7.2 R116.1
  other v1: 1949.37,279.06 2029.37,279.06 2099.37,279.06
NetC30_1: C30.1 U6.4 | length 72.5
  Bottom Layer w15: C30.1@807.1,2932.98 807.1,2887.13 U6.4@825.98,2868.25
NetC43_2: C43.2 R159.1 U8.96 | length 122
  Bottom Layer w6: R159.1@1680.49,2943.45 C43.2@1715.49,2943.45 1715.49,2963.53 1704.49,2974.53 U8.96@1704.49,3025.89
NetC44_2: C44.2 R167.1 U8.68 | length 1886
  L6-SIG2 w4.5: v1(1240.37,2795.06) 1180.43,2855 1154,2855 1094.24,2914.76 1010,2914.76 954.46,2970.3 954.46,3036.14 1073.2,3154.89 1073.2,3379.34 1132.42,3438.56 1258.87,3438.56 1274.37,3454.06 1595.37,3454.06 1627.37,3422.06 1665.37,3422.06 1716.61,3370.82 1805.82,3370.82 1829.37,3394.37 v1(1829.37,3410.87)
  Bottom Layer w6: R167.1@1207.68,2850.06 1207.68,2827.74 v1(1240.37,2795.06)
  Bottom Layer w7: U8.68@1704.49,3466.84 1762.73,3466.84 C44.2@1770.49,3459.08 1789.35,3459.08 1829.37,3419.06 v1(1829.37,3410.87)
NetC45_2: C45.2 C46.2 R169.1 U8.9 U9.1 | length 393.2
  Bottom Layer w7: C46.2@972.86,3169.06 986.2,3182.4 1040.43,3182.4 1055.25,3167.57 1055.25,3160.67 1064.05,3151.87 U8.9@1098.19,3151.87
  Bottom Layer w7.8: U9.1@880.43,3064.76 959.11,3064.76 979.69,3085.33 C45.2@979.69,3115 972.86,3121.83 C46.2@972.86,3169.06 945.32,3196.6 R169.1@945.32,3209
NetC47_2: C47.2 U8.89 Y1.3 | length 255.3
  Bottom Layer w6: U8.89@1704.49,3136.13 1742.26,3136.13 1778.18,3100.2 1860.8,3100.2 1876.31,3084.69 C47.2@1895,3084.69 Y1.3@1895,3128.2
NetC48_2: C48.2 U8.88 Y1.1 | length 177.2
  Bottom Layer w6: U8.88@1704.49,3151.87 1751.85,3151.87 1756.77,3156.8 1765.37,3156.8 Y1.1@1809.06,3200.5 ; Y1.1@1810.78,3198.78 1812.5,3200.5 Y1.1@1817.69,3200.5 ; Y1.1@1818.31,3201.12 C48.2@1818.31,3246
NetC49_2: C49.2 R180.1 U19.5 | length 115.2
  Top Layer w6: U19.5@1585.08,2055.55 1585.08,2035.41 1598.6,2021.89 C49.2@1640.09,2021.89 R180.1@1674.58,2021.89
NetC50_1: C50.1 R179.1 U18.5 | length 118.1
  Top Layer w15: C50.1@334.43,2208.11 350.54,2192 v1(361,2192)
  Bottom Layer w6: U18.5@333.74,2156.8 333.74,2207.43 R179.1@334.43,2208.11 350.54,2192 v1(361,2192)
NetC51_1: C51.1 C52.2 L5.2 U15.4 | length 232.1
  Top Layer w6: U15.4@1535.19,3183.37 1591.63,3183.37 1615,3160 C52.2@1641.38,3160 1641.38,3107.13 C51.1@1643.5,3105 1656.38,3092.13 L5.2@1656.38,3050
NetC53_1: C53.1 C54.2 L6.2 U15.9 | length 258.1
  Top Layer w6: U15.9@1535.19,3281.8 1535.19,3280.81 1623.81,3280.81 1634,3291 1644.89,3291 C54.2@1659.85,3305.96 1661.98,3308.09 C53.1@1719.85,3308.09 1722.73,3310.96 L6.2@1779.85,3310.96
NetC55_1: C55.1 R181.1 U14.8 | length 137.3
  Top Layer w6: v1(1854.37,2693.06) 1858.62,2697.31 R181.1@1858.62,2740 C55.1@1858.62,2790
  Bottom Layer w10: v1(1854.37,2693.06) 1855.85,2694.54 U14.8@1855.85,2731.03
NetC60_1: C60.1 U15.3 Y2.3 | length 440.3
  Top Layer w6: U15.3@1535.19,3163.69 1586.31,3163.69 1599.37,3150.63 1599.37,3006.88 Y2.3@1628.36,2977.89 1628.36,2986.04 1660.27,3017.95 1736.43,3017.95 C60.1@1776.38,2978
NetC61_1: C61.1 U15.2 Y2.1 | length 473.3
  Top Layer w6: U15.2@1535.19,3144 1574,3144 1580.47,3137.53 1580.47,2951.63 1595.04,2937.06 1645.57,2937.06 Y2.1@1691.35,2891.28 1748.66,2891.28 C61.1@1781.38,2924
NetC63_1: C63.1 R220.1 U16.6 | length 186.5
  Top Layer w8: v1(2464.69,3959.69) 2465.37,3960.37 v1(2465.37,4001.06) v1@2468.18,3998.24
  Bottom Layer w6: U16.6@2464.69,3935.81 v1(2464.69,3959.69)
  Bottom Layer w20: R220.1@2418.01,4098.39 2454.99,4061.42 C63.1@2454.99,4033.95 2454.99,4011.43 v1(2465.37,4001.06)
NetC74_1: C74.1 R32.2 R33.2 U3.3 | length 247.5
  Top Layer w20: U3.3@1243.6,1609.28 1326.37,1609.28 1336.37,1599.28 v1(1337.62,1600.53)
  Bottom Layer w15: R32.2@1243.19,1543.78 1243.19,1596.54 C74.1@1246.81,1600.16 R33.2@1301.81,1600.16 1337.25,1600.16 v1(1337.62,1600.53)
NetC78_1: C78.1 U13.2 | length 287.5
  Top Layer w6: C78.1@2154.37,1065.43 2163.37,1056.43 v1(2163.37,1027.06)
  Top Layer w10: U13.2@1957.99,1094.25 1957.99,1073.43 v1(1967.37,1064.06)
  Bottom Layer w6: v1(1967.37,1064.06) 2004.37,1027.06 v1(2163.37,1027.06)
NetC78_2: C78.2 L8.1 U13.9
  other v2: 2025.71,1169.06 2058.39,1169.06 2091.06,1169.06
NetC87_1: C87.1 R272.1 U13.1 | length 190.9
  Top Layer w15: C87.1@1919.37,1024.06 1935.35,1040.04 U13.1@1935.35,1094.25
  Top Layer w20: R272.1@1867.99,954.06 1911.93,954.06 1919.37,961.5 1919.37,1014.06 C87.1@1924.37,1019.06
NetC96_1: C96.1 U29.2 | length 277.7
  Top Layer w8: U29.2@1410.73,904.25 1417.17,904.25 v1(1434.17,921.26) ; v1(1450.71,1109.06) 1452.09,1110.43 C96.1@1479.37,1110.43
  Bottom Layer w8: v1(1434.17,921.26) 1434.17,984.28 1406,1012.44 1406,1064.35 v1(1450.71,1109.06)
NetC96_2: C96.2 L9.1 U29.9 | length 32.7
  L3-SIG1 w7.8: v2(1335.93,971.97) v2(1335.93,1004.65)
  other v2: 1335.93,1037.33
NetC108_1: C108.1 R312.1 U29.1 | length 136.5
  Top Layer w12: U29.1@1410.73,881.62 1466.81,881.62 C108.1@1469.37,879.06 1485.75,862.68 R312.1@1539.37,862.68
NetC110_1: C110.1 U31.4 | length 121.3
  Top Layer w10: v1@459.4,984.03 U31.4@497.3,984.03
  Bottom Layer w6: v1(459.37,984.06) 463.33,980.09 C110.1@541.08,980.09
NetC113_1: C113.1 U32.4 | length 105
  Top Layer w6: U32.4@713.77,1884.19 735.77,1884.19 764.9,1855.06 v1(765.37,1855.06)
  Bottom Layer w15: C113.1@761.61,1815.06 761.61,1851.77 v1@764.9,1855.06
NetC119_1: C119.1 C120.2 P1.2 R396.2 U30.3 U30.4 | length 48.5
  Bottom Layer w10: C119.1@766.31,1428 772.43,1428 v1(802.37,1398.06)
NetC119_2: C119.2 R396.1 R397.2 U30.5 | length 204.9
  Top Layer w6: U30.5@657.29,1343.38 657.29,1362.98 684.74,1390.42 R397.2@684.74,1409.01 681.37,1412.38 v1(681.37,1438.06) 716.32,1438.06 R396.1@725.37,1429.01
  Bottom Layer w10: v1(681.37,1438.06) 716.89,1438.06 C119.2@726.94,1428
NetD1_1: D1.1 F1.1 FB1.1 FB2.1 | length 80.7
  Top Layer w50: v1(2449.37,59.06) 2449.37,61.97 2489.37,101.97 F1.1@2474.37,116.97
  other v1: 2379.37,59.06 2529.37,59.06
NetD4_1: D4.1 R191.1 | length 96.3
  Top Layer w6: v1(2567.37,4221.06) 2567.37,4264.4 D4.1@2568.03,4265.06
  Bottom Layer w15: v1(2567.37,4221.06) 2586.75,4240.43 R191.1@2586.75,4265.06
NetD5_1: D5.1 R10.2 | length 52.9
  Top Layer w6: R10.2@757.37,201.38 761,197.75 D5.1@761,150
NetD6_1: D6.1 R251.2 | length 47.9
  Top Layer w6: R251.2@827,193.38 829.94,190.43 D6.1@829.95,146.65
NetD7_1: D7.1 R252.2 | length 47.1
  Top Layer w6: R252.2@898,193.38 898.94,192.43 D7.1@898.94,146.65
NetD8_1: D8.1 R253.2 | length 49.8
  Top Layer w6: R253.2@962.5,193.38 970,185.88 D8.1@970,146.65
NetD9_1: D9.1 R254.1 | length 83.3
  Top Layer w6: D9.1@2648.4,4338.43 v1(2683.01,4338.43)
  Bottom Layer w6: R254.1@2634.94,4338.43 R254.1@2638.99,4338.43 ; R254.1@2638.99,4337.06 2681.64,4337.06 v1(2683.01,4338.43)
NetD10_1: D10.1 R255.1 | length 52
  Top Layer w6: R255.1@690.26,200.38 693,197.64 D10.1@693,149.54
NetD11_2: D11.2 R313.1 | length 60.9
  Top Layer w20: v1(2572.7,697.54) D11.2@2572.7,726.34
  Bottom Layer w20: v1(2572.7,697.54) R313.1@2572.7,729.59
NetD14_2: D14.2 R293.1 | length 56.7
  Top Layer w15: v1(2644.37,699.06) D14.2@2644.37,726.34
  Bottom Layer w15: v1(2644.37,699.06) R293.1@2644.37,728.43
NetDS1_1: DS1.1 R114.1 | length 91.2
  Top Layer w6: v1(2680.37,1831.06) 2680.37,1798.17 DS1.1@2683.54,1795
  Bottom Layer w6: R114.1@2671.06,1781.06 2671.06,1821.74 v1(2680.37,1831.06)
NetDS1_2: DS1.2 Q1.3 | length 77.5
  Top Layer w6: Q1.3@2552.61,1786.06 2617.51,1786.06 DS1.2@2626.46,1795
NetDS2_1: DS2.1 R118.1 | length 50.6
  Top Layer w10: R118.1@2644.06,4393.06 2661.6,4393.06 DS2.1@2685,4416.46
NetDS2_2: DS2.2 Q2.3 | length 73.4
  Top Layer w6: Q2.3@2612.24,4475 2683.54,4475 DS2.2@2685,4473.54
NetDS3_1: DS3.1 R123.1 | length 37.1
  Top Layer w6: DS3.1@624,146.65 624,181.85 R123.1@625.37,183.22
NetDS4_1: DS4.1 R125.1 | length 37
  Top Layer w6: R125.1@553,183.22 554,182.22 DS4.1@554,146.65
NetF1_2: F1.2 P2.1
NetJ1_1: J1.1 R2.2 U1.7 | length 1859
  Top Layer w6: v1(1265.21,1787.6) 1265.21,1813.84 1274,1822.63 U1.7@1307.59,1822.63
  L8-SIG3 w4: v1(1265.21,1787.6) 1313.39,1739.43 1395.6,1739.43 1535.37,1599.66 1535.37,1439.39 1595.76,1379 1635.89,1379 1645.89,1389 1809.11,1389 1875.11,1323 2131.1,1323 2164.1,1290 2307.63,1290 v1(2427.69,1410.06)
  Bottom Layer w15: R2.2@2427.69,1485 v1(2427.69,1410.06) 2485.54,1352.2 J1.1@2595,1352.2
NetJ1_3: J1.3 R7.1 U1.6 | length 1844.7
  Top Layer w6: U1.6@1307.59,1872.63 1396.16,1872.63 v1(1399.62,1869.17)
  L8-SIG3 w4: v1(1399.62,1869.17) 1399.62,1750.62 1547.37,1602.88 1547.37,1468.33 1589.84,1425.86 1657.7,1425.86 1687.63,1455.79 1687.63,1535.67 1761.96,1610 2265.16,1610 2335.16,1540 2407.09,1540 v1(2427.68,1560.59)
  Bottom Layer w15: R7.1@2427.68,1525 v1(2427.68,1560.59) 2432.63,1560.59 2499.84,1627.8 J1.3@2595,1627.8
NetJ2_1: J2.1 R11.2 U3.7 | length 1806.7
  Top Layer w6: v1(1404.37,1649.28) 1414.37,1659.28 U3.7@1458.17,1659.28
  L8-SIG3 w4: v1(1404.37,1649.28) 1379.37,1624.28 1379.37,1592.06 1401.95,1569.48 1412.25,1569.48 1473.57,1508.15 1473.57,1252.43 1544,1182 1769,1182 1943.14,1007.86 2494.35,1007.86 J2.1@2595,907.2 J2.1@2593.65,905.86
  Bottom Layer w12: v1(1404.37,1649.28) R11.2@1434.54,1649.28
NetJ2_3: J2.3 R31.1 U3.6 | length 1526.9
  Top Layer w6: v1(1406.37,1599.28) 1416.37,1609.28 U3.6@1458.17,1609.28
  L8-SIG3 w4: v1(1406.37,1599.28) 1485.57,1520.07 1485.57,1440.09 1559.66,1366 1646.31,1366 1658.31,1378 1804.14,1378 1870.14,1312 2124.21,1312 2160.21,1276 2361,1276 2391,1306 2471.8,1306 J2.3@2595,1182.8
  Bottom Layer w12: v1(1406.37,1599.28) R31.1@1434.54,1599.28
NetJ3_1: J3.1 R14.2 | length 50
  Top Layer w6: R14.2@2460,4645 J3.1@2509.96,4645
NetJ5_13: J5.13 R77.2 | length 122.1
  Bottom Layer w10: R77.2@196.35,3044.06 209.95,3030.46 295.08,3030.46 J5.13@307.63,3043
NetJ5_15: J5.15 R79.2 | length 113.9
  Bottom Layer w6: R79.2@200.37,2941.06 209.37,2950.06 283.37,2950.06 290.43,2943 J5.15@307.63,2943
NetJ5_17: J5.17 R82.2 | length 96.7
  Bottom Layer w10: R82.2@211.36,2844.06 212.42,2843 J5.17@307.63,2843
NetJ5_19: J5.19 R86.2 | length 98.7
  Bottom Layer w10: R86.2@209.36,2742.06 210.31,2743 J5.19@307.63,2743
NetJ6_1: J6.1 R67.2 | length 125.7
  Top Layer w6: v1@2066.31,3643 v1(2067.37,3644.06) R67.2@2131.38,3644.06
  Bottom Layer w8: J6.1@2007.63,3643 2066.31,3643 v1(2067.37,3644.06)
NetJ6_3: J6.3 R70.2 | length 116.1
  Top Layer w6: R70.2@2020.62,3543 2069.43,3543 v1(2071.37,3541.06)
  Bottom Layer w10: J6.3@2007.63,3543 2069.43,3543 v1(2071.37,3541.06)
NetJ6_6: J6.6 R72.1 | length 119.7
  Top Layer w6: v1(2165.37,3439.06) 2169.31,3443 R72.1@2217.08,3443
  Bottom Layer w10: v1(2165.37,3439.06) 2169.31,3443 J6.6@2230.07,3443
NetJ6_8: J6.8 R76.1 | length 119.4
  Top Layer w6: v1(2164.37,3359.06) R76.1@2211.38,3359.06
  Bottom Layer w10: v1(2164.37,3359.06) 2180.43,3343 J6.8@2230.07,3343
NetJ6_9: J6.9 R81.2 | length 124.4
  Top Layer w7: v1(1939.37,3242) 1993.64,3242 R81.2@1994.64,3243
  Bottom Layer w7: v1(1939.37,3242) 2006.63,3242 J6.9@2007.63,3243
NetJ6_10: J6.10 R78.1 | length 89.2
  Top Layer w6: R78.1@2243.06,3243 2245.38,3240.68 v1(2245.38,3202.06)
  Bottom Layer w6: J6.10@2230.07,3243 2245.38,3227.69 v1(2245.38,3202.06)
NetJ6_12: J6.12 R85.1 R393.1 | length 162.3
  Top Layer w6: R393.1@2245,3102.99 2241.35,3106.64 R85.1@2241.35,3144.06 2294.37,3144.06 v1(2295.37,3143.06)
  Bottom Layer w10: J6.12@2230.07,3143 2295.31,3143 v1(2295.37,3143.06)
NetJ6_13: J6.13 R88.2 | length 122.3
  Bottom Layer w6: R88.2@1909.37,2985.04 1929.44,3005.11 1945.43,3005.11 1983.31,3043 J6.13@2007.63,3043
NetJ6_14: J6.14 R89.1 R394.1 | length 179.3
  Top Layer w6: v1(2169.37,3039.06) 2201.06,3039.06 2216.06,3024.06 R89.1@2222.01,3030 2222.01,3063.01 R394.1@2206,3079.02
  Bottom Layer w10: v1(2169.37,3039.06) 2226.13,3039.06 J6.14@2230.07,3043
NetJ6_15: J6.15 R90.2 | length 118.5
  Top Layer w6: R90.2@2020.62,2943 2061.31,2943 2061.37,2943.06 v1(2073.37,2943.06)
  Bottom Layer w10: J6.15@2007.63,2943 2073.31,2943 v1(2073.37,2943.06)
NetJ6_16: J6.16 R91.1 | length 108.1
  Top Layer w6: v1(2170.37,2945.06) 2172.43,2943 R91.1@2217.08,2943
  Bottom Layer w10: v1(2170.37,2945.06) 2172.43,2943 J6.16@2230.07,2943
NetJ6_17: J6.17 R93.2 | length 113.6
  Top Layer w6: v1(1944.37,2843.06) 1944.43,2843 R93.2@1994.64,2843
  Bottom Layer w10: v1(1944.37,2843.06) 1944.43,2843 J6.17@2007.63,2843
NetJ6_18: J6.18 R92.1 | length 110.5
  Top Layer w6: v1(2168.37,2843.06) 2168.43,2843 R92.1@2217.08,2843
  Bottom Layer w10: v1(2168.37,2843.06) 2168.43,2843 J6.18@2230.07,2843
NetJ6_19: J6.19 R94.2 | length 153.5
  Top Layer w6: v1(1941.37,2784.06) 1982.43,2743 R94.2@1994.64,2743
  Bottom Layer w10: v1(1941.37,2784.06) 1982.43,2743 J6.19@2007.63,2743
NetJ9_12: J9.12 R245.2 | length 142.8
  Top Layer w6: J9.12@143.57,1395.05 202.14,1395.05 v1(218.62,1411.53)
  Bottom Layer w10: R245.2@167.2,1434.42 195.74,1434.42 v1(218.62,1411.53)
NetJ10_1: J10.1 J10.2 J10.3 R235.1 | length 208.5
  Top Layer w10: J10.3@403.5,3226.33 459.35,3226.33 v1(467.75,3234.73) 456.46,3246.02 J10.1@403.5,3246.02 ; J10.2@629.09,3246.02 v1(700.98,3246.02)
  other v1: 711.6,3283.04
NetJ11_1: J11.1 R154.1
NetJ11_5: J11.5 R156.2 | length 113.8
  Bottom Layer w15: R156.2@2498.62,3180.55 2546.28,3228.21 J11.5@2592.69,3228.21
NetJ11_6: J11.6 J11.7 J11.8 J11.9 J11.10 J11.11 R153.2 U7.1 | length 260.9
  Top Layer w20: v1(2411.86,3245) 2411.86,3208.14 2439.03,3180.97 J11.10@2592.69,3180.97
  Bottom Layer w6: v1(2411.86,3245) 2411.86,3252.96 2423.22,3264.31 U7.1@2431.17,3264.31
NetJ12_1: J12.1 R219.1
NetJ12_6: J12.6 J12.7 J12.8 J12.9 J12.10 J12.11 R227.2
NetJ17_58: J17.58 J17.59 J17.60 R232.1 | length 214.3
  Top Layer w6: J17.58@789.69,4607.26 J17.58@790,4606.95
  Top Layer w12: J17.59@547,4626.65 621.35,4626.65 v1(630.5,4617.5) ; 737.39,4614.57 745.01,4606.95 J17.58@790,4606.95
  Bottom Layer w6: R232.1@556.77,4581.14 623.46,4581.14 v1(626.37,4584.06)
NetJ19_5: J19.5 R34.1 | length 196
  Bottom Layer w6: R34.1@2476.37,2511.06 2476.37,2516.06 2501.31,2541 J19.5@2657,2541
NetJ27_1: J27.1 R329.1 | length 104.7
  Bottom Layer w20: R329.1@714.25,1096.53 798.53,1096.53 J27.1@813,1111
NetJ27_3: J27.3 R367.2 | length 95
  Bottom Layer w6: R367.2@718,911 J27.3@813,911
NetJ28_1: J28.1 R368.1 | length 109.4
  Bottom Layer w10: R368.1@771.99,1699.06 874.37,1699.06 J28.1@879.37,1704.06
NetJ28_3: J28.3 R370.2 | length 117.1
  Bottom Layer w10: R370.2@770.99,1525.06 858.37,1525.06 J28.3@879.37,1504.06
NetL7_1: L7.1 U12.5 | length 81
  Top Layer w12: 1044.15,1673.06 1051.15,1680.06 U12.5@1068.6,1680.06
  Top Layer w15: L7.1@993.37,1666.06 1037.15,1666.06 1044.15,1673.06
NetP4_1: P4.1 R134.2 | length 111.2
  Top Layer w6: R134.2@194.68,786.31 194.68,680.35 P4.1@198.37,676.66
NetP5_1: P5.1 R138.2 | length 358.7
  Top Layer w6: P5.1@198.37,476.8 259.37,537.8 259.37,709.06 317.18,766.87 R138.2@317.18,786.31
NetP6_1: P6.1 R142.2 | length 644.1
  Top Layer w6: P6.1@198.37,279.06 288.37,369.06 288.37,680.06 316.37,708.06 366.88,708.06 434.59,775.77 R142.2@434.59,795.77
NetQ1_1: Q1.1 R117.2 | length 93.6
  Top Layer w6: R117.2@2391.31,1864.53 2433.7,1864.53 2458.13,1840.1 Q1.1@2458.13,1823.46
NetQ2_1: Q2.1 R128.2 | length 62.9
  Top Layer w6: R128.2@2455.37,4513.74 2456.71,4512.4 Q2.1@2517.76,4512.4
NetR1_1: R1.1 R4.2 R5.1 U1.8 | length 903.8
  Top Layer w6: U1.8@1307.59,1772.63 1356,1772.63 1376.63,1752 1539.11,1752 1585.99,1705.12 1706.3,1705.12 1728.92,1727.74 1728.92,1845.8 1714.25,1860.47 R1.1@1624,1860.47 1624,1863 1587.94,1899.06 v1(1578.37,1899.06)
  Bottom Layer w6: R5.1@1530,1899.68 1577.74,1899.68 v1(1578.37,1899.06) 1578.37,1839.29 1564.08,1825 R4.2@1539.69,1825
NetR6_2: R6.2 U1.1 | length 72.9
  Top Layer w6: U1.1@1514.28,1772.63 1555.53,1772.63 1574.31,1753.85 R6.2@1579.38,1753.85
NetR8_2: R8.2 U1.4 | length 61.9
  Top Layer w6: U1.4@1514.28,1922.63 1563.16,1922.63 R8.2@1572.38,1931.85
NetR12_2: R12.2 U3.8 | length 106.3
  Top Layer w8: U3.8@1458.17,1709.28 1515.37,1709.28 v1(1518.62,1712.53)
  Bottom Layer w12: R12.2@1481.79,1699.28 1507.37,1699.28 1518.62,1710.53 v1(1518.62,1712.53) v1@1519.62,1712.53
NetR15_1: R15.1 U3.5 | length 89.1
  Top Layer w8: v1(1403.88,1549.28) 1413.88,1559.28 U3.5@1458.17,1559.28
  Bottom Layer w12: v1(1403.88,1549.28) R15.1@1434.54,1549.28
NetR16_2: R16.2 U10.13 | length 82.6
  Top Layer w6: R16.2@543.87,2131.43 544,2131.3 v1(544,2080)
  Bottom Layer w6: U10.13@535.99,2107.81 535.99,2090.43 544,2082.42 v1(544,2080)
NetR17_2: R17.2 U5.13 | length 80.8
  Bottom Layer w6: U5.13@688.87,2500.62 707.68,2500.62 731.06,2524 R17.2@760.01,2524
NetR41_2: R41.2 U36.13 | length 99
  Top Layer w6: v1(801.37,2067.06) 803.75,2064.68 R41.2@834.37,2064.68
  Bottom Layer w6: U36.13@765.61,2024.68 778.99,2024.68 784.17,2029.86 784.17,2038.86 801.37,2056.06 v1(801.37,2067.06)
NetR43_1: R43.1 R200.1 R205.1 U15.39 | length 198.1
  Top Layer w6: R200.1@1000.47,3299.15 1017.38,3316.06 v1(1031.37,3316.06) 1031.37,3314.48 1044.37,3301.48 U15.39@1098.19,3301.48
  Bottom Layer w6: R205.1@1000.47,3299.15 1006.15,3299.15 1023.06,3316.06 v1(1031.37,3316.06) 1031.37,3323.63 1005.94,3349.06 R43.1@1000.99,3349.06
NetR47_2: R47.2 U8.111 | length 118
  Bottom Layer w6: U8.111@1424.96,2966.84 1424.96,2942.08 1435.76,2931.28 1444.53,2931.28 1475.75,2900.06 R47.2@1475.75,2875.06
NetR48_2: R48.2 U8.112 | length 96
  Bottom Layer w6: U8.112@1409.21,2966.84 1409.21,2935.78 1399.8,2926.37 1399.8,2905.25 R48.2@1421.37,2883.68
NetR49_2: R49.2 U31.1 | length 184.1
  Top Layer w6: v1(517,1126) 557.43,1126 572.1,1111.32 U31.1@572.1,1084.42
  Bottom Layer w6: v1(517,1126) 517,1181.69 524.37,1189.06 R49.2@554.28,1189.06
NetR50_2: R50.2 U32.1 | length 130.1
  Top Layer w6: v1(608.37,1780.06) 608.57,1779.86 U32.1@638.97,1779.86
  Bottom Layer w10: R50.2@519.37,1805.14 520.57,1803.95 584.48,1803.95 v1(608.37,1780.06)
NetR51_1: R51.1 R74.2 R124.2 | length 192.5
  Bottom Layer w6: R124.2@2589.69,2165 2614.45,2165 2637.78,2141.67 2675.31,2141.67 2684.69,2151.04 R74.2@2684.69,2200 R51.1@2684.69,2235
NetR62_2: R62.2 U33.13 | length 89.4
  Top Layer w6: v1(1379.37,2125.06) 1390.56,2113.87 U33.13@1409.35,2113.87
  Bottom Layer w6: v1(1379.37,2125.06) 1384.56,2130.24 R62.2@1431.97,2130.24
NetR63_2: R63.2 U24.13 | length 123.2
  Bottom Layer w6: U24.13@681.87,2350.57 699.85,2350.57 749.23,2399.95 R63.2@784.64,2399.95
NetR65_2: R65.2 U34.13 | length 123.8
  Bottom Layer w6: R65.2@1225.37,1961.06 R65.2@1231.37,1967.06 ; R65.2@1225.37,1967.06 R65.2@1231.37,1967.06 ; U34.13@1315.13,1982.54 1315.13,1991.8 1307.87,1999.06 1279.06,1999.06 1247.06,1967.06 R65.2@1231.37,1967.06
NetR66_2: R66.2 U25.13 | length 81.4
  Top Layer w6: v1(1442.37,2602.06) 1442.74,2602.06 1452.8,2592 U25.13@1464.81,2592
  Bottom Layer w6: v1(1442.37,2602.06) 1461.74,2602.06 1463.92,2599.87 R66.2@1496.31,2599.87
NetR68_2: R68.2 U35.13 | length 67.8
  Bottom Layer w6: R68.2@936.99,1838.06 936.99,1858.56 947.76,1869.32 U35.13@947.76,1901.38
NetR71_1: R71.1 R80.2 R129.2 | length 546.3
  Bottom Layer w6: R80.2@2550.31,2200 R71.1@2550.31,2235 2550.31,2277.16 2563.82,2290.67 2699.24,2290.67 2712.57,2277.34 2712.57,1985.26 R129.2@2710,1982.69
NetR97_1: R97.1 U4.16 | length 73
  Bottom Layer w6: U4.16@1934.46,2059.62 1987.41,2059.62 R97.1@2001.58,2073.8
NetR98_1: R98.1 U4.19 | length 81.7
  Bottom Layer w9: U4.19@1934.46,2000.57 1956.11,2000.57 1956.22,2000.46
  Bottom Layer w15: 1956.11,1998.25 1958.24,1998.25 1959.14,1997.36 1974.54,1997.36 1985.84,1986.06 R98.1@2003.58,2003.8
NetR99_1: R99.1 U4.6 | length 69.8
  Bottom Layer w6: R99.1@1716.25,2056.8 1719.08,2059.62 U4.6@1784.85,2059.62
NetR100_1: R100.1 U4.5 | length 76.1
  Bottom Layer w6: R100.1@1716.25,2021.8 1735.56,2021.8 1753.7,2039.94 U4.5@1784.85,2039.94
NetR119_1: R119.1 SW1.4 | length 99.1
  Top Layer w6: SW1.4@2428.5,2617.71 2431.37,2620.58 v1(2431.37,2656.06)
  Bottom Layer w6: v1(2431.37,2656.06) 2456,2631.43 R119.1@2456,2606.69
NetR121_1: R121.1 R126.2 SW1.2 | length 129.5
  Top Layer w6: SW1.2@2365.5,2617.71 2365.5,2642.56 2375,2652.06 v1(2391.37,2652.06)
  Bottom Layer w6: v1(2391.37,2652.06) 2398.69,2644.74 R126.2@2398.69,2619 2398.69,2589.7 R121.1@2391.98,2583
NetR127_2: R127.2 SW2.2 | length 104.9
  Top Layer w6: v1(2575,2095) 2584.21,2095 SW2.2@2613.5,2065.71 SW2.2@2623.5,2065.71
  Bottom Layer w6: R127.2@2559,2057.37 2559,2079 v1(2575,2095)
NetR132_1: R132.1 R133.2 R134.1 R135.2 | length 120.1
  Top Layer w6: R134.1@194.68,825.68 194.1,826.26 R132.1@154.22,826.26 153.22,827.26 R135.2@153.22,861.27 188.58,861.27 R133.2@194.68,867.37
NetR136_1: R136.1 R137.2 R138.1 R139.2 | length 123.9
  Top Layer w6: R138.1@317.18,825.68 316.6,826.26 R137.2@274.06,826.26 274.06,861.1 R136.1@274.22,861.27 311.08,861.27 R139.2@317.18,867.37
NetR140_1: R140.1 R141.2 R142.1 R143.2 | length 134.8
  Top Layer w6: R143.2@395.5,818.64 418.09,818.64 R142.1@434.59,835.14 R140.1@434.59,875.77 417.62,875.77 R141.2@395.5,853.64
NetR148_2: R148.2 U6.5 | length 67.9
  Bottom Layer w15: R148.2@856.1,2933.18 863.38,2925.9 U6.5@863.38,2868.25
NetR157_2: R157.2 U8.33 | length 105.6
  Bottom Layer w7: R157.2@1091.99,3623.06 1098.05,3617 1147,3617 1157.24,3606.76 U8.33@1157.24,3573.13
NetR158_1: R158.1 U8.95 | length 86
  Bottom Layer w6: U8.95@1704.49,3041.64 1738.68,3041.64 R158.1@1775.32,3005
NetR160_2: R160.2 U8.34 | length 143.6
  Bottom Layer w7: R160.2@1091.99,3673.06 1110.73,3654.31 1128.07,3654.31 1172.99,3609.4 U8.34@1172.99,3573.13
NetR161_2: R161.2 R162.2 U8.25 | length 294.5
  Top Layer w6: R162.2@1003.37,3500 R162.2@1007.99,3500 ; R161.2@1007.99,3463 R162.2@1007.99,3500 ; v1(1151,3412) 1151,3441.43 1092.43,3500 R162.2@1007.99,3500
  Bottom Layer w6: U8.25@1098.19,3403.84 1142.84,3403.84 v1(1151,3412)
NetR163_1: R163.1 U8.63 | length 82.7
  Bottom Layer w7: R163.1@1625.49,3654.08 1629.68,3649.88 U8.63@1629.68,3573.13
NetR164_1: R164.1 U8.62 | length 90.7
  Bottom Layer w7: R164.1@1590.49,3654.08 1613.93,3630.63 U8.62@1613.93,3573.13
NetR165_1: R165.1 U8.61 | length 98.6
  Bottom Layer w7: R165.1@1555.49,3654.08 1598.19,3611.38 U8.61@1598.19,3573.13
NetR166_1: R166.1 U8.60 | length 119
  Bottom Layer w7: R166.1@1515.49,3654.08 1544.56,3625 1562.23,3625 1582.44,3604.79 U8.60@1582.44,3573.13
NetR168_1: R168.1 U8.70 | length 1144.2
  L6-SIG2 w4.5: v1(898,3217) 933.16,3217 946.37,3230.21 946.37,3287.15 1122.27,3463.06 1248.72,3463.06 1270.72,3485.06 1687.94,3485.06 v1(1750,3423)
  Bottom Layer w6: v1(898,3217) 905.13,3217 911.93,3223.8 920.37,3223.8 932.2,3235.63 932.2,3244.07 R168.1@947.12,3258.99
  Bottom Layer w7: U8.70@1704.49,3435.34 1737.66,3435.34 v1(1750,3423)
NetR170_2: R170.2 U8.59 | length 141.7
  Bottom Layer w7: R170.2@1475.49,3654.08 1518.56,3611 1557.85,3611 1566.69,3602.16 U8.59@1566.69,3573.13
NetR171_2: R171.2 U18.1 | length 47.4
  Bottom Layer w6: U18.1@353.43,2098.53 353.43,2100.65 R171.2@398.74,2100.65
NetR172_2: R172.2 U19.4 | length 36.9
  Top Layer w6: R172.2@1565.39,2018.61 U19.4@1565.39,2055.55
NetR173_2: R173.2 U19.1 | length 35.9
  Top Layer w6: U19.1@1604.76,2113.82 1604.76,2148.47 R173.2@1605.67,2149.37
NetR174_1: R174.1 U18.6 | length 52.2
  Bottom Layer w6: U18.6@353.43,2156.8 353.43,2153.6 389.81,2153.6 R174.1@398.74,2144.67
NetR175_1: R175.1 U19.6 | length 51.2
  Top Layer w6: U19.6@1604.76,2055.55 1635.55,2055.55 R175.1@1650,2070
NetR176_2: R176.2 U18.3 | length 49.6
  Bottom Layer w6: R176.2@295,2057.58 294.06,2058.53 314.06,2078.53 U18.3@314.06,2098.53
NetR177_2: R177.2 U19.3 | length 132.3
  Top Layer w6: v1(1529.37,2165.06) 1565.39,2129.03 U19.3@1565.39,2113.82
  Bottom Layer w12: v1(1529.37,2165.06) 1565.39,2129.03 R177.2@1565.39,2113.82
NetR178_1: R178.1 U18.4 | length 94.4
  Bottom Layer w6: R178.1@294.37,2243.07 294.37,2203.69 314.06,2184 U18.4@314.06,2156.8
NetR182_1: R182.1 U15.16 | length 180.7
  Top Layer w6: U15.16@1535.19,3419.59 1535.19,3452.19 1582.78,3499.78 R182.1@1582.78,3580.56
NetR183_1: R183.1 U15.17 | length 138.2
  Top Layer w6: U15.17@1464.33,3490.46 1498,3490.46 1529.74,3522.2 1529.74,3577.52 R183.1@1532.78,3580.56
NetR184_1: R184.1 U15.18 | length 104.6
  Top Layer w6: U15.18@1444.64,3490.46 1444.64,3528.27 1479.59,3563.22 R184.1@1479.59,3580.56
NetR188_1: R188.1 U15.19 | length 452.2
  Top Layer w6: U15.19@1424.96,3490.46 1424.96,3526.96 1453,3555 1453,3729.43 v1(1445.37,3737.06)
  Bottom Layer w10: R188.1@1339.85,3645.96 1359.27,3645.96 1371,3657.69 1371,3722 1398,3749 1433.43,3749 v1(1445.37,3737.06)
NetR192_1: R192.1 R195.1 U15.27 | length 146.3
  Top Layer w6: R192.1@1262.78,3580.56 R192.1@1267.48,3575.86 ; U15.27@1267.48,3490.46 R192.1@1267.48,3575.86 ; R195.1@1319.78,3580.56 1315.09,3575.86 R192.1@1267.48,3575.86
NetR193_2: R193.2 U14.4 | length 187.1
  Top Layer w6: R193.2@1728.62,2790 1750.31,2790 v1(1769.37,2809.06)
  Bottom Layer w6: U14.4@1631.44,2807.8 1768.12,2807.8 v1(1769.37,2809.06)
NetR194_1: R194.1 U15.26 | length 145.5
  Top Layer w6: U15.26@1287.16,3490.46 1287.16,3534.16 1298.58,3545.58 1334.8,3545.58 R194.1@1369.78,3580.56
NetR196_1: R196.1 U15.28 | length 184.6
  Top Layer w6: R196.1@1212.37,3660.43 1241.37,3631.43 1241.37,3551.97 1247.79,3545.55 U15.28@1247.79,3490.46
NetR197_1: R197.1 U15.30 | length 181.6
  Top Layer w6: U15.30@1208.42,3490.46 1208.42,3614.11 v1(1213.37,3619.06)
  Bottom Layer w8: R197.1@1210.49,3668.76 1210.49,3621.94 v1(1213.37,3619.06)
NetR198_1: R198.1 U15.32 | length 150.9
  Top Layer w6: R198.1@1070.99,3572.06 1101.05,3542 1150,3542 1169.05,3522.95 U15.32@1169.05,3490.46
NetR199_1: R199.1 U15.34 | length 96.7
  Top Layer w6: R199.1@1003.62,3405 1038,3405 1043.09,3399.91 U15.34@1098.19,3399.91
NetR201_2: R201.2 U15.6 | length 117.3
  Top Layer w6: U15.6@1535.19,3222.74 1575,3222.74 1594.74,3203 1634.38,3203 R201.2@1641.38,3210
NetR202_1: R202.1 U15.38 | length 140.2
  Top Layer w6: v1(1041,3350) 1041,3341.43 1061.26,3321.17 U15.38@1098.19,3321.17
  Bottom Layer w6: R202.1@999.99,3399.06 1041,3358.05 v1(1041,3350)
NetR204_2: R204.2 U15.14 | length 123.1
  Top Layer w6: U15.14@1535.19,3380.22 1572.44,3380.22 1607.78,3415.56 1607.78,3451.16 R204.2@1608,3451.38
NetR206_1: R206.1 U15.43 | length 107.5
  Top Layer w6: R206.1@1000.47,3199.15 1025.16,3199.15 1048.74,3222.74 U15.43@1098.19,3222.74
NetR207_1: R207.1 U15.44 | length 125.1
  Top Layer w6: R207.1@1000.47,3149.15 1003.15,3149.15 1012,3158 1012,3166.69 1048.36,3203.06 U15.44@1098.19,3203.06
NetR208_1: R208.1 U15.45 | length 169.3
  Top Layer w6: R208.1@1000.47,3094.15 1032.28,3094.15 1054.75,3116.63 1054.75,3175.75 1062.37,3183.37 U15.45@1098.19,3183.37
NetR210_1: R210.1 R211.1 U15.52 | length 236.5
  Top Layer w6: R210.1@1157.78,2883.8 1208.93,2883.8 1208.93,2914.93 1237.53,2943.53 1237.53,2984.72 1228.11,2994.14 U15.52@1228.11,3053.45
NetR212_1: R212.1 U15.53 | length 239.2
  Top Layer w6: U15.53@1247.79,3053.45 1247.79,3007.21 1253.48,3001.52 1253.48,2931.97 1238,2916.49 1238,2849.43 1244.37,2843.06 R212.1@1261.75,2843.06
NetR213_1: R213.1 U15.54 | length 164.8
  Top Layer w6: R213.1@1261.75,2891.06 1266.17,2895.48 1266.17,3052.14 U15.54@1267.48,3053.45
NetR214_1: R214.1 U15.55 | length 204.5
  Top Layer w6: U15.55@1287.16,3053.45 1287.16,2994.86 1281.5,2989.2 1281.5,2954.49 1300.94,2935.06 1321.99,2935.06 R214.1@1360.37,2896.68 ; R214.1@1359.37,2896.68 R214.1@1359.37,2897.06
NetR215_1: R215.1 U15.57 | length 227.3
  Top Layer w6: U15.57@1326.53,3053.45 1326.53,3005.48 1346,2986.02 1377.03,2986.02 1405.9,2957.15 1405.9,2899.84 R215.1@1421.93,2883.8
NetR216_1: R216.1 U15.58 | length 242.5
  Top Layer w6: U15.58@1346.22,3053.45 1346.22,3018.24 1366.44,2998.02 1382,2998.02 1417.9,2962.12 1417.9,2943.36 1442.2,2919.06 1461.37,2919.06 1472.93,2907.49 R216.1@1472.93,2883.8
NetR217_1: R217.1 U15.59 | length 261
  Top Layer w6: U15.59@1365.9,3053.45 1365.9,3015.52 1371.41,3010.02 1386.97,3010.02 1429.9,2967.09 1429.9,2948.33 1447.17,2931.06 1475.99,2931.06 R217.1@1523.37,2883.68
NetR218_1: R218.1 U15.36 | length 106.9
  Top Layer w6: R218.1@1003.62,3350 1023.82,3370.2 1049.37,3370.2 1059.03,3360.54 U15.36@1098.19,3360.54
NetR222_1: R222.1 R225.1 U17.5 | length 391.2
  Top Layer w6: U17.5@1387.48,2666.61 1431.81,2666.61 v1(1436.37,2662.06)
  Bottom Layer w6: R222.1@1220,2597.76 1258.76,2559 1302.09,2559 1322.09,2539 1372.6,2539 1400,2566.4 R225.1@1400,2627.57 1423.88,2627.57 1436.37,2640.06 v1(1436.37,2662.06)
NetR223_2: R223.2 U16.5 | length 128.5
  Top Layer w6: v1(2426,3970) 2445.17,3989.17 2445.17,4009.42 2453.62,4017.88 R223.2@2453.62,4045
  Bottom Layer w6: v1(2426,3970) 2426,3956 2445,3937 U16.5@2445,3935.81
NetR261_2: R261.2 U2.13 | length 100.2
  Top Layer w6: v1(2292.37,1823.31) 2293.22,1822.46 R261.2@2330.6,1822.46
  Bottom Layer w6: U2.13@2260.78,1871.87 2260.78,1854.9 v1(2292.37,1823.31)
NetR262_2: R262.2 U28.13 | length 99.4
  Top Layer w6: v1(1294,2305) 1311.9,2305 1322.76,2294.14 U28.13@1322.76,2278.62
  Bottom Layer w6: v1(1294,2305) 1316.38,2305 R262.2@1336.38,2285
NetR271_1: R271.1 U13.18 | length 117.8
  Top Layer w6: R271.1@1864.37,1285.43 1864.37,1238.63 1894.06,1208.94 1922.56,1208.94 U13.18@1922.56,1208.43
NetR299_1: R299.1 R308.2 U11.1 | length 221.4
  Top Layer w10: R299.1@2294.05,1619.06 v1(2320,1645) 2338.83,1663.83 2338.83,1694.65 R308.2@2340.51,1696.33
  Bottom Layer w10: v1(2320,1645) 2320,1710 2341.43,1731.43 U11.1@2371.03,1731.43
NetR301_1: R301.1 R311.2 U20.1 | length 96.2
  Top Layer w6: U20.1@1852.76,2572.32 1888.78,2572.32 R311.2@1904.41,2556.69 1904.41,2523.41 R301.1@1901.05,2520.06
NetR303_1: R303.1 U11.5 | length 114.2
  Top Layer w8: R303.1@2380,1674.02 2395.98,1674.02 v1(2425,1645)
  Bottom Layer w6: U11.5@2371.03,1652.69 2417.31,1652.69 v1(2425,1645)
NetR304_1: R304.1 U20.2 U20.5 | length 182.5
  Top Layer w6: U20.2@1852.76,2592.01 1821.99,2592.01 1815,2599 1815,2642 1824.06,2651.06 U20.5@1852.76,2651.06 1885.63,2651.06 R304.1@1902.91,2668.35
NetR305_1: R305.1 U11.2 U11.4 | length 454
  Bottom Layer w6: R305.1@2219.37,1566.69 2327.52,1566.69 2375.83,1615 2435,1615 2445.2,1625.2 2445.2,1653.37 2426.2,1672.37 U11.4@2371.03,1672.37 2347.63,1672.37 2340.39,1679.61 2340.39,1707.13 2345,1711.74 U11.2@2371.03,1711.74
NetR306_1: R306.1 U20.4 | length 53.1
  Top Layer w6: U20.4@1852.76,2631.38 1899.72,2631.38 R306.1@1904.09,2627.01
NetR307_2: R307.2 U11.3 | length 170.6
  Top Layer w8: R307.2@2334.69,1755 2386.91,1755 v1(2418.97,1722.94)
  Bottom Layer w8: U11.3@2371.03,1692.06 2409.06,1692.06 2418.97,1701.97 v1(2418.97,1722.94)
NetR309_1: R309.1 U29.18 | length 153.6
  Top Layer w8: v1(1259.37,849.06) 1276.79,849.06 U29.18@1296.55,868.82
  Bottom Layer w10: R309.1@1168.99,892.06 1216.37,892.06 v1(1259.37,849.06)
NetR310_2: R310.2 U20.3 | length 59.9
  Top Layer w6: U20.3@1852.76,2611.69 1884.41,2611.69 R310.2@1904.41,2591.69
NetR312_2: R312.2 U29.19 | length 370.6
  Top Layer w8: v1(1282.72,824.06) 1300.66,842 1308.41,842 1316.24,849.84 U29.19@1316.24,868.82
  Top Layer w10: v1(1539.37,782.06) R312.2@1539.37,815.43
  Bottom Layer w8: v1(1282.72,824.06) 1283.92,822.86 1498.57,822.86 v1(1539.37,782.06)
NetR314_1: R314.1 R327.2 U21.1 | length 96.6
  Bottom Layer w6: R327.2@1690.12,1403.27 R314.1@1690.12,1443.27 1709.41,1443.27 1716.58,1436.1 U21.1@1743.74,1436.1
NetR316_1: R316.1 R330.2 U22.1 | length 89.8
  Bottom Layer w6: R316.1@1640.79,2572.32 U22.1@1685.43,2572.32 ; R316.1@1642.99,2570.12 1641.35,2568.47 1641.35,2530.39 R330.2@1644.68,2527.06
NetR317_1: R317.1 R332.2 U23.2 | length 87.3
  Top Layer w6: U23.2@1911.06,1455.78 1959.19,1455.78 R317.1@1960.94,1457.53 1960.94,1440.45 1957.87,1437.38 R332.2@1957.87,1422.07
NetR319_1: R319.1 U21.5 | length 77.1
  Bottom Layer w6: R319.1@1678.43,1543.27 1706.86,1514.84 U21.5@1743.74,1514.84
NetR320_1: R320.1 U22.2 U22.5 | length 173.1
  Bottom Layer w6: R320.1@1655.36,2678.06 1655.36,2654.84 1659.14,2651.06 U22.5@1685.43,2651.06 1709.36,2651.06 1721,2639.43 1721,2600.69 1712.32,2592.01 U22.2@1685.43,2592.01
NetR321_1: R321.1 U23.1 U23.5 | length 224.7
  Top Layer w6: U23.1@1911.06,1436.1 1886.89,1436.1 1874.93,1448.06 1874.93,1503.06 1886.71,1514.84 1931.93,1514.84 1940.57,1523.48 1940.57,1547.48 1959.78,1566.69 R321.1@1963.11,1566.69
NetR322_1: R322.1 U21.2 U21.4 | length 175.6
  Bottom Layer w6: R322.1@1678.43,1513.27 1690.65,1501.06 1706.84,1501.06 1712.75,1495.15 U21.4@1743.74,1495.15 1772.66,1495.15 1779.37,1488.44 1779.37,1462.5 1772.66,1455.78 U21.2@1743.74,1455.78
NetR323_1: R323.1 U22.4 | length 136.4
  Bottom Layer w6: R323.1@1575.36,2675.06 1591.17,2659.25 1591.17,2645.26 1605.05,2631.38 U22.4@1685.43,2631.38
NetR324_1: R324.1 U23.4 | length 65.4
  Top Layer w6: U23.4@1911.06,1495.15 1931.37,1495.15 1937.06,1500.84 1937.73,1500.84 1963.11,1526.22 R324.1@1963.11,1526.69
NetR325_2: R325.2 U21.3 | length 54.8
  Bottom Layer w6: R325.2@1690.12,1478.27 1702.37,1478.27 1705.17,1475.47 U21.3@1743.74,1475.47
NetR326_2: R326.2 U31.5 | length 104
  Top Layer w10: v1(508.62,942.53) 521,954.91 521,962 534.7,975.7 U31.5@534.7,984.03
  Bottom Layer w6: v1(508.62,942.53) 508.62,936.68 R326.2@541.08,904.23
NetR328_2: R328.2 U22.3 | length 47.8
  Bottom Layer w6: R328.2@1641.03,2603.47 1649.25,2611.69 U22.3@1685.43,2611.69
NetR331_2: R331.2 U23.3 | length 60.9
  Top Layer w6: U23.3@1911.06,1475.47 1937.46,1475.47 1955.05,1493.06 R331.2@1964.68,1493.06
NetR338_2: R338.2 U26.13 | length 77.2
  Top Layer w6: R338.2@1333.99,2468.06 1387.37,2468.06 1402.25,2453.17 U26.13@1405,2453.17
NetR339_2: R339.2 U27.13 | length 80.9
  Top Layer w6: R339.2@751.37,2219.06 785.97,2219.06 v1(798.17,2206.86)
  Bottom Layer w6: U27.13@769.61,2205.68 796.99,2205.68 v1(798.17,2206.86)
NetR363_2: R363.2 U32.5 | length 213.1
  Top Layer w6: v1(643.37,1815.06) 643.37,1829 676.37,1862 U32.5@676.37,1880.25 U32.5@676.37,1884.19
  Bottom Layer w8: R363.2@539.37,1878.43 566.19,1878.43 595.37,1849.26 609.17,1849.26 v1(643.37,1815.06)
NetR395_2: R395.2 U30.8 | length 36.2
  Top Layer w6: R395.2@621.37,1267.37 622.13,1266.61 U30.8@657.29,1266.61
PGOOD: J10.13 R75.1 R150.1 R224.1 R276.1 R290.2 | length 2196
  Top Layer w6: v1(234.37,3148.06) 237.37,3148.06 257.52,3127.91 J10.13@403.5,3127.91
  L6-SIG2 w4.5: v1(234.37,3148.06) 196.74,3110.42 196.74,3044.33 222.61,3018.46 338.54,3018.46 438.14,2918.86 547.86,2918.86 637,3008 637,3059 693,3115 756.17,3115 823.98,3047.19 823.98,2872.64 927.84,2768.78 1072.22,2768.78 v1(1083,2758) 1099.29,2741.71 1210.72,2741.71 1233.57,2718.86 1271.17,2718.86 1313.56,2761.24 1357.56,2761.24 v1(1371.37,2775.06)
  Bottom Layer w6: R150.1@1079.6,2789.93 1079.6,2761.4 v1(1083,2758)
  Bottom Layer w10: R224.1@183.62,3178 R276.1@183.62,3129 215.31,3129 v1(234.37,3148.06) 234.37,3176.25 R75.1@183.62,3227 ; v1(1371.37,2775.06) 1376.12,2779.81 R290.2@1400.28,2779.81
PMIC_1V0: C15.2 L3.2 R288.1 U4.1 U23.8 U23.10 | length 794.6
  Top Layer w8: U23.10@1743.74,1436.1 1783.21,1436.1 v1(1800.37,1453.26) 1778.16,1475.47 U23.8@1743.74,1475.47
  Bottom Layer w10: v1(1679.37,1599.06) 1686.41,1606.1 R288.1@1729.17,1606.1 1736.41,1606.1 v1(1789.37,1659.06) ; v1(1789.37,1559.06) 1789.37,1581.84 C15.2@1812.7,1605.17
  Bottom Layer w14.5: L3.2@1714.65,1684.12 1645.73,1684.12 1617,1712.85 1617,1859.65 1647.35,1890 1672,1890 1700.47,1918.47 1737,1918.47 1750.01,1931.48 1750.01,1947.53 1760.73,1958.25 U4.1@1784.85,1958.25
PMIC_1V2: C14.2 L2.2 R287.1 U4.14 U22.8 U22.10 | length 711.4
  Bottom Layer w10: U22.8@1852.76,2611.69 1822.01,2611.69 1809.37,2599.06 1809.37,2579.06 1816.1,2572.32 U22.10@1852.76,2572.32 1886.1,2572.32 1909.37,2549.06 1909.37,2489.06
  Bottom Layer w14.5: U4.14@1934.46,2101.95 1958.57,2101.95 1969.29,2112.67 1969.29,2128.71 1982.3,2141.72
  Bottom Layer w15: 1982.3,2141.72 1984.67,2144.09 1984.67,2149.29 1999.14,2163.76 2076.66,2163.76 2091.59,2178.69 2091.59,2340.09 2056.88,2374.8 L2.2@2003.22,2374.8 L2.2@1998.42,2374.8
PMIC_1V8: C16.2 L4.2 R286.1 U4.21 U21.8 U21.10 | length 721.7
  Bottom Layer w6: v1@1827.4,1477.09 v1(1831.37,1481.06) v1@1836.96,1475.47
  Bottom Layer w9.84: v1@1827.4,1477.09 1827.4,1445.03 1849.37,1423.06 1868.37,1423.06 1881.41,1436.1 U21.10@1911.06,1436.1 ; v1@1836.96,1475.47 U21.8@1911.06,1475.47
  Bottom Layer w14.5: U4.21@1934.46,1958.25 1942.52,1958.25 2007.37,1893.4
  Bottom Layer w15: v1(1899.37,1656.06) 1918.37,1675.06 v1(1918.37,1697.06) ; L4.2@1998.42,1685.39 2053.49,1685.39 2084.64,1716.55 2084.64,1725.29 2093.6,1734.25 2093.6,1875.16 2075.36,1893.4 2007.37,1893.4
  other v1: 1936.37,1659.06
PMIC_3V3: C13.2 L1.2 R289.1 U4.8 U20.10 | length 543.6
  Top Layer w9.8: U20.10@1685.43,2572.32 1716.1,2572.32 1739.37,2549.06
  Top Layer w15: 1739.37,2549.06 1749.37,2539.06 v1(1749.37,2499.06)
  Bottom Layer w14.5: 1633,2265.26 1633,2170.4 1639.89,2163.51 1719.5,2163.51 1750.01,2132.99 1750.01,2112.67 1760.73,2101.95 U4.8@1784.85,2101.95
  Bottom Layer w15: 1633,2265.26 1633,2279.01 1687.76,2333.77 1687.76,2358.54 L1.2@1704.02,2374.8
PMIC_CLK: R131.2 U4.3 | length 2239.5
  Top Layer w6: R131.2@246.68,954.08 v1(246.68,983.7)
  Bottom Layer w6: v1(246.68,983.7) 466.57,1203.59 466.57,1305.26 531.37,1370.06 786.6,1370.06 822.09,1334.57 960.22,1334.57 1029.77,1404.12 1029.77,1482.63 1135,1587.86 1135,1681 1163.26,1709.26 1273.26,1709.26 1298,1734 1358.46,1734 1397.96,1773.51 1397.96,1818.96 1425,1846 1425,1885.92 1470.13,1931.06 1504.25,1931.06 1587.04,2013.85 1635.05,2013.85 1643.85,2005.06 1751.37,2005.06 1755.86,2000.57 U4.3@1784.85,2000.57
PMIC_EN: J17.50 R353.1 R354.1 R356.1 R398.1 | length 261.4
  Top Layer w6: v1(722.63,4531) 725.48,4528.15 J17.50@790,4528.15
  Bottom Layer w6: v1@725.48,4528.15 730.28,4523.35 R354.1@766.38,4523.35 ; R398.1@766.38,4423.35 R356.1@766.38,4473.35 R354.1@766.38,4523.35 ; R353.1@766.38,4573.35 R354.1@766.38,4523.35
PMIC_EN1: R108.1 R400.2 U4.7 | length 633.6
  Top Layer w6: v1(1709.37,2139.06) 1728.43,2139.06 1757.06,2110.43 2137.99,2110.43 v1(2174.37,2074.06)
  Bottom Layer w6: v1(1709.37,2139.06) 1717.89,2139.06 1725.95,2130.99 R400.2@1725.95,2113.8 1725.95,2113.75 1760.39,2079.31 U4.7@1784.85,2079.31 ; R108.1@2143.05,2074.06 v1(2174.37,2074.06)
PMIC_EN2: R109.1 R401.2 U4.15 | length 419.2
  L3-SIG1 w4: v1(2009.37,2139.06) 2009.37,2055.06 v1(2144.43,1920)
  Bottom Layer w6: U4.15@1934.46,2079.31 1972.09,2079.31 R401.2@2001.58,2108.8 2001.58,2131.27 v1(2009.37,2139.06) ; v1(2144.43,1920) 2144.43,1944.43 R109.1@2149.37,1949.37
PMIC_EN3: R110.1 R402.2 U4.2 | length 567.1
  Top Layer w10: v1(1745.37,1980.88) 1760.49,1996 2132.51,1996 v1(2176.97,2040.46)
  Bottom Layer w6: v1(1745.37,1980.88) U4.2@1784.85,1980.88 ; R110.1@2141.37,2040.46 v1(2176.97,2040.46)
  Bottom Layer w10: R402.2@1714.06,1970.06 1734.54,1970.06 v1(1745.37,1980.88)
PMIC_NRST: R107.2 R399.2 U4.20 | length 174.2
  Bottom Layer w8: U4.20@1934.46,1980.88 1944.54,1980.88 1971.63,1953.8 R399.2@2001.58,1953.8 2001.58,1956.27 2017.95,1972.64 2056.49,1972.64 2061.76,1967.37 2061.76,1963.62 R107.2@2076.27,1949.11
PMIC_PGOOD: R106.2 R111.2 R276.2 | length 2342.4
  Top Layer w6: v1(140.37,3090.06) 152.91,3090.06 201.75,3041.22 201.75,3039.32 203.38,3037.68 203.38,2709.51 317.89,2595 406.28,2595 505.28,2496 565.62,2496 611.47,2450.15 669.64,2450.15 690.46,2470.97 690.46,2492.51 769.72,2571.77 863.68,2571.77 892.23,2543.22 986.87,2543.22 1022.49,2507.6 1096.87,2507.6 1112.92,2491.55 1112.92,2348.98 1121.9,2340 1396.05,2340 1425.99,2310.06 1506.31,2310.06 1526.05,2329.8 1562.25,2329.8 1579.37,2346.92 v1(1579.37,2389.5)
  Bottom Layer w6: v1(1579.37,2389.5) 1579.37,2389.06 1594.81,2389.06 R106.2@1621.41,2362.46 1621.09,2362.14 R111.2@1621.09,2324.46
  Bottom Layer w10: R276.2@136.38,3129 136.38,3094.05 v1(140.37,3090.06)
PMICVIO_3V3: R97.2 R98.2 R105.1 R107.1 R108.2 R109.2 R110.2 R112.2 | length 325.8
  Bottom Layer w15: R97.2@2040.95,2073.8 2061.37,2073.8 2063.03,2075.46 2102.28,2075.46 R108.2@2103.68,2074.06 ; R98.2@2042.95,2003.8 2050.08,2003.8 2065.4,1988.48 R107.1@2076.27,1988.48 2111.27,1988.48 2144.36,1988.48 R109.2@2144.62,1988.22 ; R112.2@2102.68,2108.06 2103.68,2107.06 R108.2@2103.68,2074.06 ; R108.2@2103.68,2074.06 2103.68,2042.14 R110.2@2102,2040.46 2102,2026.22 2112.22,2016 ; 2112.22,2016 2112.22,1990.89 R105.1@2114.37,1988.74 2114.37,2013.85 2112.22,2016
RADAR_BSS_LOGGER_SPIB_CS: J4.43 R162.1 U34.10 | length 4019.7
  Top Layer w6: v1(967.37,3552.06) 982.01,3537.42 R162.1@982.01,3500 ; J4.43@1838.5,4468.95 1922.75,4468.95 v1(1923.2,4469.4)
  L8-SIG3 w4: v1(967.37,3552.06) 1000.57,3518.86 1000.57,3327.82 957,3284.26 903.14,3284.26 848.37,3229.49 848.37,3149.56 866.65,3131.28 866.65,3087.41 888.1,3065.96 888.1,3017.49 959.54,2946.06 991.51,2946.06 1077.37,2860.2 1077.37,2824.43 1063,2810.06 1063,2735.86 1072.86,2726 1108.32,2726 1125,2709.32 1125,2654.57 1151.57,2628 1151.57,2520 1112.33,2480.76 1112.33,1958.94 1151.48,1919.79 1220.13,1919.79 v1(1243.87,1896.06)
  Bottom Layer w6: v1(967.37,3552.06) 967.37,3569.47 987.4,3589.5 987.4,3882.09 1086.16,3980.84 1401.84,3980.84 1569.46,4148.46 1569.46,4182.42 1597.79,4210.75 1890.92,4210.75 1918.83,4238.66 1918.83,4283.03 1867.43,4334.43 1867.43,4453.37 1883.46,4469.4 v1(1923.2,4469.4) ; v1(1243.87,1896.06) 1243.87,1916.93 1254.37,1927.43 U34.10@1307.25,1927.43
RADAR_DMM_CLK: J4.10 J9.13 J10.15 R36.2 | length 6339.6
  Top Layer w6: v1(233.95,3052.66) 233.95,3085.99 258.86,3110.9 330.69,3110.9 ; v1(296.37,1416.06) 297.69,1414.73 J9.13@369.17,1414.73 ; 330.4,3111.2 330.69,3110.9 ; J10.15@403.5,3108.22 333.37,3108.22 330.69,3110.9 ; J4.10@2081.5,4134.05 2133.01,4134.05 2145.27,4121.79 2163,4121.79 2174.27,4133.06 v1(2213.37,4133.06)
  L6-SIG2 w4.5: v1(233.95,3052.66) 391.34,3052.66 404,3040 480,3040 513.37,3073.37 513.37,3197 535.37,3219 578,3219 590,3207 750.31,3207 854.37,3311.06 952.59,3311.06 1117.1,3475.56 1243.55,3475.56 1334.04,3566.06 1751.09,3566.06 1783.21,3533.94 1908.87,3533.94 1969.37,3594.44 1969.37,3922.17 1980.83,3933.63 1980.83,4044.49 2013.4,4077.06 2037.94,4077.06 2058.37,4097.49 2058.37,4134.31 2141.26,4217.2 2158,4217.2 2213.37,4161.83 v1(2213.37,4133.06)
  L8-SIG3 w4: v1(233.95,3052.66) 216.75,3069.86 99.2,3069.86 67.37,3038.03 67.37,2480.5 297.5,2250.37 297.5,1899.19 215.37,1817.06 215.37,1497.06 v1(296.37,1416.06) 277.42,1397.11 277.42,1241.11 171.17,1134.86 171.17,893.83 234,831 365,831 389.37,806.63 v1(389.37,789.06)
  Bottom Layer w6: v1(389.37,789.06) 396.94,796.62 R36.2@567,796.62
RADAR_DMM_SYNC: J4.8 J10.17 R20.1 R35.1 | length 5317.7
  Top Layer w6: J10.17@403.5,3088.54 454.54,3088.54 v1(468,3102) ; R20.1@551.88,1343.95 586.73,1343.95 v1(587.35,1343.32) ; v1(2020.37,4098.06) 2036.66,4114.35 J4.8@2081.5,4114.35
  L3-SIG1 w4: v1(468,3102) 469.94,3100.06 507.24,3100.06 591.2,3016.1 591.2,2966.87 632.57,2925.5 632.57,2669.75 560.5,2597.67 560.5,2585.4 554.17,2579.07 554.17,2522.68 526.55,2495.06 507.37,2495.06 457.46,2445.14 457.46,2324.28 470.17,2311.57 470.17,2276.96 488.2,2258.93 488.2,2242.51 547.97,2182.73 547.97,2172.16 587.88,2132.26 605.74,2132.26 679.1,2058.9 679.1,2016.63 671.37,2008.9 671.37,1923.49 745.17,1849.69 745.17,1744.41 745.57,1744.01 745.57,1728.1 745.17,1727.7 745.17,1463.74 645.48,1364.06 608.09,1364.06 v1(587.35,1343.32)
  L6-SIG2 w4.5: v1(468,3102) 501.37,3135.37 501.37,3216.37 522,3237 592,3237 611,3218 744.34,3218 827,3300.66 827,3355.72 868.14,3396.86 1021.42,3396.86 1112.12,3487.56 1238.58,3487.56 1331.07,3580.06 1758.73,3580.06 1792.75,3546.04 1903.23,3546.04 1953.37,3596.18 1953.37,3910.06 1940.43,3923 1940.43,4021.06 2017.43,4098.06 v1(2020.37,4098.06)
  L8-SIG3 w4: v1(539.37,849.06) 576.57,886.26 576.57,980.58 567.15,990 567.15,1106.62 554,1119.77 554,1309.97 v1(587.35,1343.32)
  Bottom Layer w6: v1(539.37,849.06) 564.57,849.06 R35.1@617,796.62
RADAR_DP0: J4.27 J10.19 R21.1 R38.1 | length 6744.6
  Top Layer w6: v1(313.43,3086.72) 331.29,3068.85 J10.19@403.5,3068.85 ; R21.1@551.88,1393.95 586.73,1393.95 v1(587.35,1393.32) ; J4.27@1838.5,4311.35 1838.5,4312.2 1923.23,4312.2 v1(1923.37,4312.06)
  L3-SIG1 w4: v1(587.35,1393.32) 408.37,1572.3 408.37,1751.06 315.52,1843.9 292.37,1843.9 234.99,1901.29 234.99,2051.13 267.09,2083.24 267.09,2221.48 167.57,2321 167.57,3027.57 249.9,3109.9 290.24,3109.9 v1(313.43,3086.72) 352.57,3125.86 352.57,3291.43 134.17,3509.83 134.17,4547.03 341,4753.86 1693.3,4753.86 1798.2,4648.95 1798.2,4625.76 1901.16,4522.8 1921.63,4522.8 1960,4484.42 1960,4385.69 1940.17,4365.86 1940.17,4328.86 v1(1923.37,4312.06)
  L8-SIG3 w4: v1(587.35,1393.32) 628.5,1393.32 658.29,1363.53 658.29,1247.98 636.37,1226.06 636.37,1128.06 693.19,1071.24 v1(693.19,832.97)
  Bottom Layer w6: v1(693.19,832.97) 723.19,802.97 R38.1@723.19,795.28
RADAR_DP1: J4.29 J10.21 R27.1 R39.2 | length 6670.2
  Top Layer w6: J10.21@403.5,3049.17 453.17,3049.17 v1(468,3064) ; R27.1@551.88,1443.95 586.73,1443.95 v1(587.35,1443.32) ; J4.29@1838.5,4331.05 1887.36,4331.05 v1(1893.37,4337.06)
  L3-SIG1 w4: v1(587.35,1443.32) 611.64,1443.32 705.57,1537.26 705.57,1871.86 662.37,1915.06 662.37,1915.52 655.37,1922.52 655.37,1984.03 582.56,2056.84 582.56,2085.16 537.97,2129.74 537.97,2177.03 478.2,2236.8 478.2,2254.79 460.17,2272.82 460.17,2307.43 445.46,2322.14 445.46,2513.71 475.8,2544.06 526.5,2544.06 542.18,2559.74 542.18,2584.06 548.5,2590.37 548.5,2602.64 620.57,2674.72 620.57,2921.94 581.2,2961.31 581.2,3011.95 544.3,3048.86 483.14,3048.86 v1(468,3064) 440.03,3091.97 440.03,3381.4 218.37,3603.06 218.37,4265.06 499.31,4546 545,4546 557,4534 557,4506 572,4491 650.37,4491 669.37,4510 669.37,4534.06 696.37,4561.06 793.37,4561.06 850.37,4618.06 1197.37,4618.06 1246.57,4568.86 1246.57,4556.84 1187.88,4498.15 1187.88,4486.13 1199.9,4474.11 1211.92,4474.11 1281.34,4543.53 1293.36,4543.53 1305.38,4531.51 1305.38,4519.49 1235.96,4450.06 1235.96,4438.04 1247.98,4426.02 1260,4426.02 1318.69,4484.71 1330.71,4484.71 1478.37,4337.06 v1(1893.37,4337.06)
  L8-SIG3 w4: v1(587.35,1443.32) 560.62,1416.59 560.62,1378.2 571.72,1367.1 632.19,1367.1 643.62,1355.67 643.62,1261.31 566,1183.68 566,1124.74 582.37,1108.37 582.37,998 588.57,991.8 588.57,879.94 635.54,832.97 v1(638.19,832.97)
  Bottom Layer w6: v1(638.19,832.97) 668.19,802.97 R39.2@668.19,795.28