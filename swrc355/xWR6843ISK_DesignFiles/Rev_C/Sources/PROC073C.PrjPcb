# Altium project PROC073C.PrjPcb (part 3 of 3)

## Sheet PROC073C_EVM_Hardware.SchDoc: Hardware
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 13; Revision: Use project parameter SCH_Rev; SheetNumber: 13; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
!PCB  Printed Circuit Board  (value not drawn)  (mechanical)
CAUTION_HOT_SURFACE1  CAUTION HOT SURFACE  [IEC_HotSurface_Small]  (no BOM)
FID1  Fiducial  [Fiducial10-20]  (value not drawn)
FID2  Fiducial  [Fiducial10-20]  (value not drawn)
FID3  Fiducial  [Fiducial10-20]  (value not drawn)
FID4  Fiducial  [Fiducial10-20]  (value not drawn)
FID5  Fiducial  [Fiducial10-20]  (value not drawn)
FID6  Fiducial  [Fiducial10-20]  (value not drawn)
H1  560-338  (mechanical)
H2  560-338  (mechanical)
H3  560-338  (mechanical)
H4  560-338  (mechanical)
H5  4708  (mechanical)
H6  4708  (mechanical)
H7  4708  (mechanical)
H8  4708  (mechanical)
H9  24430  (mechanical)
H10  24430  (mechanical)
H11  24430  (mechanical)
H12  24430  (mechanical)
H13  91420A126  [FP-91420A126_SCREW_M3X0.5-MFG]  (mechanical)
H14  91420A126  [FP-91420A126_SCREW_M3X0.5-MFG]  (mechanical)
H15  91420A126  [FP-91420A126_SCREW_M3X0.5-MFG]  (mechanical)
H16  91420A126  [FP-91420A126_SCREW_M3X0.5-MFG]  (mechanical)
LBL1  THT-14-423-10  Note: Size: 0.65" x 0.20 "  [Label_650x200]
Logo1  Texas Instruments  [TI_Stacked_Overlay_Small]  (no BOM)
Logo2  CE Mark  [CE_Mark_5mm]  (no BOM)
Logo3  FCC disclaimer  [FCC_disclaimer]  (no BOM)
Logo4  WEEE logo  [WEEE_Minimum]  (no BOM)
Logo5  Texas Instruments  [TI_Symbol_Overlay_Small]  (no BOM)
ZZ1  This Assembly Note is for PCB labels only  [AssemblyNoteLabel]  (no BOM)
ZZ2  These assemblies are ESD sensitive, ESD precautions shall be observed.  [AssemblyNote]  (no BOM)
ZZ3  These assemblies must be clean and free from flux and all contaminants. Use of no clean flux is not acceptable.  [AssemblyNote]  (no BOM)
ZZ4  These assemblies must comply with workmanship standards IPC-A-610 Class 2, unless otherwise specified.  [AssemblyNote]  (no BOM)
ZZ5  INDICATION FOR COMPONENTS D* ARE GIVEN AT THEIR CATHODE SIDE.  [AssemblyNote]  (no BOM)

### Notes on the sheet
- Variant
- 001_IWR
- Variant/Label Table
- Label Text
- IWR6843ISK
- 002_AWR
- AWR6843ISK

### Library data of the parts
!PCB = CMP-0003618-2: Manufacturer: Any; PartNumber: PROC073
CAUTION_HOT_SURFACE1 = CMP-0074837-1: IEC 61010-1 Hot Surface Warning; Library Reference: IEC_HotSurface; SymbolCreator: a0412235
FID1-FID6 = CMP-0077181-1: Fiducial mark.  There is nothing to buy or mount.
H1-H4 = CMP-0084015-1: Steel Plain Washer; Manufacturer: RS Pro
H5-H8 = CMP-0003742-1: HEX NUT 0.217" STEEL M3; Manufacturer: Keystone; CompType: Standoff
H9-H12 = CMP-0003759-1: HEX Standoff M3 Aluminum 5 MM; Manufacturer: Keystone
H13-H16 = CMP-0086605-1: Steel Phillips Flat Head Screws M3 x 0.5 mm Thread, 16 mm Long; Manufacturer: McMaster-Carr
LBL1 = CMP-0003625-1: Thermal Transfer Printable Labels, 0.650" W x 0.200" H - 10,000 per roll; Manufacturer: Brady; CompType: Label
Logo1 = CMP-0074838-1: Texas Instrument Corporate Signature; SymbolCreator: a0412235; Lib Reference: TI_Logo; Library Reference: Logo
Logo2 = CMP-0074844-1: SymbolCreator: a0412235
Logo3 = CMP-0074847-1: FCC_disclaimer; Library Reference: Logo
Logo4 = CMP-0074769-1
Logo5 = CMP-0074838-1: Texas Instrument Corporate Signature; Library Reference: Logo; SymbolCreator: a0412235; Lib Reference: TI_Logo
ZZ1 = CMP-0003616-3
ZZ2 = CMP-0077236-1
ZZ3 = CMP-0077237-1
ZZ4 ZZ5 = CMP-0077238-1

## Nets that join several sheets
5V_IN: PROC073C_PMIC (12 pins), PROC073C_Flash_USB_To_UART (D2.1 R90.1), PROC073C_HD_DCA_Conn (R141.1), PROC073C_Can_Interface (R69.2 R82.2)
CB_PMIC_1V0: PROC073C_PMIC (R199.2), PROC073C_Decoupling_caps (C2.2 C3.2 L2.1 L3.1), PROC073C_HD_Connector_60Pin (J1.1 J1.3), PROC073C_Temp_Current_sensor (U7.9)
CB_PMIC_1V2: PROC073C_PMIC (R193.2), PROC073C_Decoupling_caps (C64.2 L7.1), PROC073C_HD_Connector_60Pin (J1.5 J1.7), PROC073C_Temp_Current_sensor (U8.9)
CB_PMIC_1V8: PROC073C_PMIC (R192.2 R195.1), PROC073C_Decoupling_caps (C1.2 L1.1), PROC073C_HD_Connector_60Pin (J1.9), PROC073C_Temp_Current_sensor (U6.9)
CONN_5V: PROC073C_HD_Connector_60Pin (J1.2 J2.58 J2.59 J2.60), PROC073C_Flash_USB_To_UART (C50.1 R102.1 U16.8), PROC073C_HD_DCA_Conn (R122.1 TP13.1)
GND: PROC073C_PMIC (29 pins), PROC073C_IWR6843_Chip (77 pins), PROC073C_Decoupling_caps (39 pins), PROC073C_QSPI_Flash_section (C34.1 C35.1 U2.4 U2.9), PROC073C_HD_Connector_60Pin (23 pins), PROC073C_Temp_Current_sensor (23 pins), PROC073C_Flash_USB_To_UART (25 pins), PROC073C_HD_DCA_Conn (20 pins), PROC073C_SOP_Ctrl (5 pins), PROC073C_Can_Interface (15 pins)
PMIC_1V0: PROC073C_PMIC (C66.1 L6.1 R199.1 U4.1), PROC073C_Temp_Current_sensor (U7.8 U7.10)
PMIC_1V2: PROC073C_PMIC (C62.1 L5.1 R193.1 U4.14), PROC073C_Temp_Current_sensor (U8.8 U8.10)
PMIC_1V8: PROC073C_PMIC (C67.1 L8.1 R192.1 U4.21), PROC073C_Temp_Current_sensor (U6.8 U6.10)
PMICOUT_3V3: PROC073C_PMIC (L11.1 R198.2 TP10.1), PROC073C_Flash_USB_To_UART (9 pins), PROC073C_SOP_Ctrl (S1.10 S1.11 S1.12)
RADAR_1P0_RF1: PROC073C_IWR6843_Chip (U1.G5 U1.H5 U1.J5), PROC073C_Decoupling_caps (5 pins)
RADAR_1P0_RF2: PROC073C_IWR6843_Chip (U1.C2 U1.D2), PROC073C_Decoupling_caps (6 pins)
RADAR_1V2: PROC073C_IWR6843_Chip (6 pins), PROC073C_Decoupling_caps (9 pins)
RADAR_1V4_APLL: PROC073C_IWR6843_Chip (U1.A10), PROC073C_Decoupling_caps (C22.2)
RADAR_1V4_SYNTH: PROC073C_IWR6843_Chip (U1.B13), PROC073C_Decoupling_caps (C18.2)
RADAR_1V8: PROC073C_IWR6843_Chip (6 pins), PROC073C_Decoupling_caps (11 pins)
RADAR_3V3: PROC073C_PMIC (R184.2 R200.2), PROC073C_IWR6843_Chip (7 pins), PROC073C_Decoupling_caps (C16.2 C17.2 C21.2), PROC073C_Temp_Current_sensor (U10.9)
RADAR_VBGAP: PROC073C_IWR6843_Chip (U1.B10), PROC073C_Decoupling_caps (C6.2)
RADAR_VOUT_PA: PROC073C_IWR6843_Chip (U1.A2 U1.B2), PROC073C_Decoupling_caps (C4.2 C7.2 C8.2 R1.2)
VCC_3V3: PROC073C_PMIC (7 pins), PROC073C_QSPI_Flash_section (R43.2 R44.2 R49.2 R50.1), PROC073C_HD_Connector_60Pin (6 pins), PROC073C_Temp_Current_sensor (27 pins), PROC073C_HD_DCA_Conn (6 pins), PROC073C_Can_Interface (9 pins)
VCC_LD_SW_3V3: PROC073C_PMIC (5 pins), PROC073C_Temp_Current_sensor (U10.8 U10.10)
VPP_1P7: PROC073C_IWR6843_Chip (C31.2 U1.L13), PROC073C_HD_Connector_60Pin (J2.57 TP14.1)
CONN_RS232RX: PROC073C_HD_Connector_60Pin (R38.1), PROC073C_Flash_USB_To_UART (U15.7), PROC073C_HD_DCA_Conn (J6.55)
CONN_RS232TX: PROC073C_HD_Connector_60Pin (R40.1), PROC073C_Flash_USB_To_UART (U15.9), PROC073C_HD_DCA_Conn (J6.57)
MUX_IN_1: PROC073C_SOP_Ctrl (S1.4), PROC073C_Can_Interface (R88.1 U13.15)
MUX_IN_2: PROC073C_Flash_USB_To_UART (R100.1 U15.1 U15.5), PROC073C_SOP_Ctrl (S1.5)
PGOOD: PROC073C_PMIC (R179.1 R182.2 R198.1 R201.2), PROC073C_HD_Connector_60Pin (R13.2), PROC073C_HD_DCA_Conn (J6.13)
PMIC_CLK: PROC073C_PMIC (U4.3), PROC073C_SOP_Ctrl (R202.2)
PMIC_EN1: PROC073C_PMIC (R188.1 U4.7), PROC073C_HD_Connector_60Pin (R140.1)
RADAR_BSS_LOGGER: PROC073C_IWR6843_Chip (U1.H14), PROC073C_HD_Connector_60Pin (R60.2)
RADAR_CS1: PROC073C_IWR6843_Chip (R156.1 U1.E15), PROC073C_Can_Interface (U13.10)
RADAR_DMM_CLK: PROC073C_IWR6843_Chip (U1.N15), PROC073C_HD_Connector_60Pin (R15.1), PROC073C_HD_DCA_Conn (J6.15)
RADAR_DMM_SYNC: PROC073C_IWR6843_Chip (U1.N14), PROC073C_HD_Connector_60Pin (R17.1), PROC073C_HD_DCA_Conn (J6.17)
RADAR_DP0: PROC073C_IWR6843_Chip (U1.R4), PROC073C_HD_Connector_60Pin (R18.1), PROC073C_HD_DCA_Conn (J6.19)
RADAR_DP1: PROC073C_IWR6843_Chip (U1.P5), PROC073C_HD_Connector_60Pin (R19.1), PROC073C_HD_DCA_Conn (J6.21)
RADAR_DP2: PROC073C_IWR6843_Chip (U1.R5), PROC073C_HD_Connector_60Pin (R20.1), PROC073C_HD_DCA_Conn (J6.23)
RADAR_DP3: PROC073C_IWR6843_Chip (U1.P6), PROC073C_HD_Connector_60Pin (R21.1), PROC073C_HD_DCA_Conn (J6.25)
RADAR_DP4: PROC073C_IWR6843_Chip (U1.R7), PROC073C_HD_Connector_60Pin (R23.1), PROC073C_HD_DCA_Conn (J6.27)
RADAR_DP5: PROC073C_IWR6843_Chip (U1.P7), PROC073C_HD_Connector_60Pin (R26.1), PROC073C_HD_DCA_Conn (J6.29)
RADAR_DP6: PROC073C_IWR6843_Chip (U1.R8), PROC073C_HD_Connector_60Pin (R27.1), PROC073C_HD_DCA_Conn (J6.31)
RADAR_DP7: PROC073C_IWR6843_Chip (U1.P8), PROC073C_HD_Connector_60Pin (R28.1), PROC073C_HD_DCA_Conn (J6.33)
RADAR_DP8: PROC073C_HD_Connector_60Pin (R124.1), PROC073C_HD_DCA_Conn (R148.1)
RADAR_DP9: PROC073C_HD_Connector_60Pin (R125.1), PROC073C_HD_DCA_Conn (R149.1)
RADAR_DP10: PROC073C_HD_Connector_60Pin (R126.1), PROC073C_HD_DCA_Conn (R163.1)
RADAR_DP11: PROC073C_HD_Connector_60Pin (R127.1), PROC073C_HD_DCA_Conn (R164.1)
RADAR_DP12: PROC073C_HD_Connector_60Pin (R128.1), PROC073C_HD_DCA_Conn (R166.1)
RADAR_DP13: PROC073C_HD_Connector_60Pin (R129.1), PROC073C_HD_DCA_Conn (R167.1)
RADAR_DP14: PROC073C_HD_Connector_60Pin (R130.1), PROC073C_HD_DCA_Conn (R168.1)
RADAR_DP15: PROC073C_HD_Connector_60Pin (R132.1), PROC073C_HD_DCA_Conn (R170.1)
RADAR_GPIO_0: PROC073C_IWR6843_Chip (U1.H13), PROC073C_HD_Connector_60Pin (R65.1), PROC073C_Can_Interface (R3.2 R216.2)
RADAR_GPIO_1: PROC073C_IWR6843_Chip (U1.J13), PROC073C_HD_Connector_60Pin (R66.2), PROC073C_HD_DCA_Conn (R214.2)
RADAR_GPIO_2: PROC073C_PMIC (R185.2), PROC073C_IWR6843_Chip (U1.K13), PROC073C_HD_Connector_60Pin (R67.2), PROC073C_HD_DCA_Conn (D7.1)
RADAR_HOSTINTR1: PROC073C_IWR6843_Chip (R152.2 U1.P13), PROC073C_HD_Connector_60Pin (R10.2), PROC073C_HD_DCA_Conn (J6.10)
RADAR_LVDS_0M: PROC073C_IWR6843_Chip (U1.J15), PROC073C_HD_Connector_60Pin (R41.2), PROC073C_HD_DCA_Conn (R230.2)
RADAR_LVDS_0P: PROC073C_IWR6843_Chip (U1.J14), PROC073C_HD_Connector_60Pin (R39.2), PROC073C_HD_DCA_Conn (R229.2)
RADAR_LVDS_1M: PROC073C_IWR6843_Chip (U1.K15), PROC073C_HD_Connector_60Pin (R35.2), PROC073C_HD_DCA_Conn (R228.2)
RADAR_LVDS_1P: PROC073C_IWR6843_Chip (U1.K14), PROC073C_HD_Connector_60Pin (R33.2), PROC073C_HD_DCA_Conn (R227.2)
RADAR_LVDS_2M: PROC073C_HD_Connector_60Pin (R137.2), PROC073C_HD_DCA_Conn (R224.2)
RADAR_LVDS_2P: PROC073C_HD_Connector_60Pin (R136.2), PROC073C_HD_DCA_Conn (R223.2)
RADAR_LVDS_3M: PROC073C_HD_Connector_60Pin (R135.2), PROC073C_HD_DCA_Conn (R222.2)
RADAR_LVDS_3P: PROC073C_HD_Connector_60Pin (R134.2), PROC073C_HD_DCA_Conn (R221.2)
RADAR_LVDS_CLKM: PROC073C_IWR6843_Chip (U1.L15), PROC073C_HD_Connector_60Pin (R32.2), PROC073C_HD_DCA_Conn (R226.2)
RADAR_LVDS_CLKP: PROC073C_IWR6843_Chip (U1.L14), PROC073C_HD_Connector_60Pin (R30.2), PROC073C_HD_DCA_Conn (R225.2)
RADAR_LVDS_FRCLKM: PROC073C_IWR6843_Chip (U1.M15), PROC073C_HD_Connector_60Pin (R24.2), PROC073C_HD_DCA_Conn (R220.2)
RADAR_LVDS_FRCLKP: PROC073C_IWR6843_Chip (U1.M14), PROC073C_HD_Connector_60Pin (R22.2), PROC073C_HD_DCA_Conn (R219.2)
RADAR_LVDS_VALIDM: PROC073C_HD_Connector_60Pin (R133.2), PROC073C_HD_DCA_Conn (R218.2)
RADAR_LVDS_VALIDP: PROC073C_HD_Connector_60Pin (R131.2), PROC073C_HD_DCA_Conn (R217.2)
RADAR_MCUCLKOUT: PROC073C_IWR6843_Chip (U1.N8), PROC073C_HD_Connector_60Pin (R62.2)
RADAR_MISO1: PROC073C_IWR6843_Chip (U1.E14), PROC073C_Can_Interface (U13.2)
RADAR_MOSI1: PROC073C_IWR6843_Chip (U1.D13), PROC073C_Can_Interface (U13.5)
RADAR_MSS_LOGGER: PROC073C_IWR6843_Chip (U1.F14), PROC073C_HD_Connector_60Pin (R31.2), PROC073C_Flash_USB_To_UART (R96.2)
RADAR_NERR_OUT: PROC073C_IWR6843_Chip (R169.1 U1.N6), PROC073C_HD_Connector_60Pin (R59.2)
RADAR_NERRIN: PROC073C_IWR6843_Chip (R150.1 U1.N7), PROC073C_HD_Connector_60Pin (R58.2)
RADAR_NRST: PROC073C_IWR6843_Chip (U1.R3), PROC073C_HD_DCA_Conn (R171.1 U17.4)
RADAR_NRST_1: PROC073C_HD_Connector_60Pin (R42.1), PROC073C_HD_DCA_Conn (J6.59 R123.2 U17.1)
RADAR_OSC_CLKOUT: PROC073C_IWR6843_Chip (U1.A14), PROC073C_HD_Connector_60Pin (R61.2)
RADAR_PMIC_CLKOUT_SOP2: PROC073C_IWR6843_Chip (U1.P9), PROC073C_HD_Connector_60Pin (R63.2), PROC073C_SOP_Ctrl (R202.1 R203.1)
RADAR_QSPI_CS: PROC073C_IWR6843_Chip (U1.P11), PROC073C_QSPI_Flash_section (R50.2 U2.1)
RADAR_QSPI_D0: PROC073C_IWR6843_Chip (U1.R13), PROC073C_QSPI_Flash_section (R45.2)
RADAR_QSPI_D1: PROC073C_IWR6843_Chip (U1.N12), PROC073C_QSPI_Flash_section (R46.1)
RADAR_QSPI_D2: PROC073C_IWR6843_Chip (U1.R14), PROC073C_QSPI_Flash_section (R44.1 R47.1)
RADAR_QSPI_D3: PROC073C_IWR6843_Chip (U1.P12), PROC073C_QSPI_Flash_section (R49.1 R51.2)
RADAR_QSPI_SCLK: PROC073C_IWR6843_Chip (U1.R12), PROC073C_QSPI_Flash_section (R48.2)
RADAR_RS232RX: PROC073C_IWR6843_Chip (R154.1 U1.N4), PROC073C_Flash_USB_To_UART (U15.6)
RADAR_RS232TX: PROC073C_IWR6843_Chip (R153.1 U1.N5), PROC073C_Flash_USB_To_UART (U15.10)
RADAR_SCL: PROC073C_PMIC (R181.1), PROC073C_IWR6843_Chip (U1.G14), PROC073C_HD_Connector_60Pin (R37.1 R53.1), PROC073C_Temp_Current_sensor (6 pins), PROC073C_HD_DCA_Conn (J6.53)
RADAR_SDA: PROC073C_PMIC (R180.1), PROC073C_IWR6843_Chip (U1.F13), PROC073C_HD_Connector_60Pin (R34.1 R52.1), PROC073C_Temp_Current_sensor (6 pins), PROC073C_HD_DCA_Conn (J6.51)
RADAR_SPICLK1: PROC073C_IWR6843_Chip (U1.E13), PROC073C_Can_Interface (U13.7)
RADAR_SYNC_IN: PROC073C_IWR6843_Chip (R155.2 U1.P4), PROC073C_HD_Connector_60Pin (R36.2), PROC073C_HD_DCA_Conn (J6.16)
RADAR_SYNC_OUT_SOP1: PROC073C_IWR6843_Chip (U1.G13), PROC073C_HD_Connector_60Pin (R16.2), PROC073C_SOP_Ctrl (R206.1)
RADAR_TCK: PROC073C_IWR6843_Chip (U1.P10), PROC073C_HD_Connector_60Pin (R6.2)
RADAR_TDI: PROC073C_IWR6843_Chip (U1.R11), PROC073C_HD_Connector_60Pin (R5.1)
RADAR_TDO_SOP0: PROC073C_IWR6843_Chip (U1.N13), PROC073C_HD_Connector_60Pin (R4.2), PROC073C_SOP_Ctrl (R209.1)
RADAR_TMS: PROC073C_IWR6843_Chip (U1.N10), PROC073C_HD_Connector_60Pin (R8.2)
RADAR_WARMRST: PROC073C_IWR6843_Chip (U1.N9), PROC073C_HD_Connector_60Pin (R64.2)
SPI_CLK1: PROC073C_HD_Connector_60Pin (R9.1), PROC073C_HD_DCA_Conn (J6.9), PROC073C_Can_Interface (U13.8)
SPI_CS1: PROC073C_HD_Connector_60Pin (R7.1), PROC073C_HD_DCA_Conn (J6.7), PROC073C_Can_Interface (U13.11)
SPI_MISO1: PROC073C_HD_Connector_60Pin (R12.2), PROC073C_HD_DCA_Conn (J6.12), PROC073C_Can_Interface (U13.1)
SPI_MOSI1: PROC073C_HD_Connector_60Pin (R11.1), PROC073C_HD_DCA_Conn (J6.11), PROC073C_Can_Interface (U13.4)

## Assembly variants
001_IWR: not fitted C8 C40 C41 C42 FID1 FID2 FID3 FID4 FID5 FID6 J2 J4 R2 R3 R14 R57 R70 R81 R82 R83 R84 R85 R86 R87 R107 R113 R114 R116 R139 R147 R157 R161 R202 R216 TP14 U12
002_AWR: not fitted C8 FID1 FID2 FID3 FID4 FID5 FID6 J2 R2 R3 R14 R57 R70 R83 R107 R113 R114 R116 R139 R147 R157 R161 R202 TP14