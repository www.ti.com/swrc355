# Altium project PROC073C.PrjPcb (part 2 of 3)

## Sheet PROC073C_HD_Connector_60Pin.SchDoc: HD Connector
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 7; Revision: Use project parameter SCH_Rev; SheetNumber: 7; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
J1  QSH-030-01-L-D-A  [Samtec_QSH-030-01-X-D-A]  (value not drawn)
J2  QSH-030-01-L-D-A  [Samtec_QSH-030-01-X-D-A]  (value not drawn)
R4  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R5  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R6  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R7  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R8  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R9  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R10  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R11  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R12  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R13  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R15  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R16  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R17  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R18  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R19  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R20  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R21  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R22  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R23  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R24  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R26  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R27  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R28  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R30  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R31  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R32  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R33  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R34  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R35  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R36  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R37  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R38  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R39  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R40  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R41  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R42  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R52  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R53  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R58  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R59  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R60  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R61  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R62  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R63  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R64  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R65  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R66  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R67  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R124  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R125  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R126  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R127  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R128  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R129  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R130  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R131  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R132  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R133  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R134  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R135  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R136  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R137  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R140  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
TP14  5001  [Keystone5001]  (value not drawn)

### Ports
CONN_RS232RX, CONN_RS232TX, PGOOD, PMIC_EN1 (out), RADAR_BSS_LOGGER, RADAR_DMM_CLK (out), RADAR_DMM_SYNC (out), RADAR_DP0 (bidir), RADAR_DP1 (bidir), RADAR_DP2 (bidir), RADAR_DP3 (bidir), RADAR_DP4 (bidir), RADAR_DP5 (bidir), RADAR_DP6 (bidir), RADAR_DP7 (bidir), RADAR_DP8, RADAR_DP9, RADAR_DP10, RADAR_DP11, RADAR_DP12, RADAR_DP13, RADAR_DP14, RADAR_DP15, RADAR_GPIO_0 (bidir), RADAR_GPIO_1 (bidir), RADAR_GPIO_2 (bidir), RADAR_HOSTINTR1, RADAR_LVDS_0M (in), RADAR_LVDS_0P (in), RADAR_LVDS_1M (in), RADAR_LVDS_1P (in), RADAR_LVDS_2M, RADAR_LVDS_2P, RADAR_LVDS_3M, RADAR_LVDS_3P, RADAR_LVDS_CLKM (in), RADAR_LVDS_CLKP (in), RADAR_LVDS_FRCLKM (in), RADAR_LVDS_FRCLKP (in), RADAR_LVDS_VALIDM, RADAR_LVDS_VALIDP, RADAR_MCUCLKOUT, RADAR_MSS_LOGGER, RADAR_NERR_OUT, RADAR_NERRIN, RADAR_NRST_1, RADAR_OSC_CLKOUT (in), RADAR_PMIC_CLKOUT_SOP2 (in), RADAR_SCL, RADAR_SDA, RADAR_SYNC_IN, RADAR_SYNC_OUT_SOP1, RADAR_TCK (out), RADAR_TDI (out), RADAR_TDO_SOP0, RADAR_TMS (out), RADAR_WARMRST, SPI_CLK1 (bidir), SPI_CS1 (bidir), SPI_MISO1, SPI_MOSI1

### Nets
CB_PMIC_1V0: J1.1 J1.3
CB_PMIC_1V2: J1.5 J1.7
CB_PMIC_1V8: J1.9
CONN_5V: J1.2 J2.58 J2.59 J2.60
GND: J1.20 J1.26 J1.32 J1.38 J1.44 J1.50 J1.MP1 J1.MP2 J1.MP3 J1.MP4 J2.19 J2.25 J2.28 J2.30 J2.31 J2.32 J2.37 J2.43 J2.56 J2.MP1 J2.MP2 J2.MP3 J2.MP4
VCC_3V3: J1.4 J1.6 J2.52 J2.54 R52.2 R53.2
VPP_1P7: J2.57 TP14.1
CONN_RS232RX: R38.1 ; port CONN_RS232RX
CONN_RS232TX: R40.1 ; port CONN_RS232TX
PGOOD: R13.2 ; port PGOOD
PMIC_EN1: R140.1 ; port PMIC_EN1
RADAR_BSS_LOGGER: R60.2 ; port RADAR_BSS_LOGGER
RADAR_DMM_CLK: R15.1 ; port RADAR_DMM_CLK
RADAR_DMM_SYNC: R17.1 ; port RADAR_DMM_SYNC
RADAR_DP0: R18.1 ; port RADAR_DP0
RADAR_DP1: R19.1 ; port RADAR_DP1
RADAR_DP2: R20.1 ; port RADAR_DP2
RADAR_DP3: R21.1 ; port RADAR_DP3
RADAR_DP4: R23.1 ; port RADAR_DP4
RADAR_DP5: R26.1 ; port RADAR_DP5
RADAR_DP6: R27.1 ; port RADAR_DP6
RADAR_DP7: R28.1 ; port RADAR_DP7
RADAR_DP8: R124.1 ; port RADAR_DP8
RADAR_DP9: R125.1 ; port RADAR_DP9
RADAR_DP10: R126.1 ; port RADAR_DP10
RADAR_DP11: R127.1 ; port RADAR_DP11
RADAR_DP12: R128.1 ; port RADAR_DP12
RADAR_DP13: R129.1 ; port RADAR_DP13
RADAR_DP14: R130.1 ; port RADAR_DP14
RADAR_DP15: R132.1 ; port RADAR_DP15
RADAR_GPIO_0: R65.1 ; port RADAR_GPIO_0
RADAR_GPIO_1: R66.2 ; port RADAR_GPIO_1
RADAR_GPIO_2: R67.2 ; port RADAR_GPIO_2
RADAR_HOSTINTR1: R10.2 ; port RADAR_HOSTINTR1
RADAR_LVDS_0M: R41.2 ; port RADAR_LVDS_0M
RADAR_LVDS_0P: R39.2 ; port RADAR_LVDS_0P
RADAR_LVDS_1M: R35.2 ; port RADAR_LVDS_1M
RADAR_LVDS_1P: R33.2 ; port RADAR_LVDS_1P
RADAR_LVDS_2M: R137.2 ; port RADAR_LVDS_2M
RADAR_LVDS_2P: R136.2 ; port RADAR_LVDS_2P
RADAR_LVDS_3M: R135.2 ; port RADAR_LVDS_3M
RADAR_LVDS_3P: R134.2 ; port RADAR_LVDS_3P
RADAR_LVDS_CLKM: R32.2 ; port RADAR_LVDS_CLKM
RADAR_LVDS_CLKP: R30.2 ; port RADAR_LVDS_CLKP
RADAR_LVDS_FRCLKM: R24.2 ; port RADAR_LVDS_FRCLKM
RADAR_LVDS_FRCLKP: R22.2 ; port RADAR_LVDS_FRCLKP
RADAR_LVDS_VALIDM: R133.2 ; port RADAR_LVDS_VALIDM
RADAR_LVDS_VALIDP: R131.2 ; port RADAR_LVDS_VALIDP
RADAR_MCUCLKOUT: R62.2 ; port RADAR_MCUCLKOUT
RADAR_MSS_LOGGER: R31.2 ; port RADAR_MSS_LOGGER
RADAR_NERR_OUT: R59.2 ; port RADAR_NERR_OUT
RADAR_NERRIN: R58.2 ; port RADAR_NERRIN
RADAR_NRST_1: R42.1 ; port RADAR_NRST_1
RADAR_OSC_CLKOUT: R61.2 ; port RADAR_OSC_CLKOUT
RADAR_PMIC_CLKOUT_SOP2: R63.2 ; port RADAR_PMIC_CLKOUT_SOP2
RADAR_SCL: R37.1 R53.1 ; port RADAR_SCL
RADAR_SDA: R34.1 R52.1 ; port RADAR_SDA
RADAR_SYNC_IN: R36.2 ; port RADAR_SYNC_IN
RADAR_SYNC_OUT_SOP1: R16.2 ; port RADAR_SYNC_OUT_SOP1
RADAR_TCK: R6.2 ; port RADAR_TCK
RADAR_TDI: R5.1 ; port RADAR_TDI
RADAR_TDO_SOP0: R4.2 ; port RADAR_TDO_SOP0
RADAR_TMS: R8.2 ; port RADAR_TMS
RADAR_WARMRST: R64.2 ; port RADAR_WARMRST
SPI_CLK1: R9.1 ; port SPI_CLK1
SPI_CS1: R7.1 ; port SPI_CS1
SPI_MISO1: R12.2 ; port SPI_MISO1
SPI_MOSI1: R11.1 ; port SPI_MOSI1
NetJ1_8: J1.8 R17.2
NetJ1_10: J1.10 R15.2
NetJ1_11: J1.11 R5.2
NetJ1_12: J1.12 R42.2
NetJ1_13: J1.13 R8.1
NetJ1_14: J1.14 R13.1
NetJ1_15: J1.15 R6.1
NetJ1_16: J1.16 R10.1
NetJ1_17: J1.17 R4.1
NetJ1_18: J1.18 R31.1
NetJ1_19: J1.19 R7.2
NetJ1_21: J1.21 R9.2
NetJ1_22: J1.22 R36.1
NetJ1_23: J1.23 R11.2
NetJ1_24: J1.24 R16.1
NetJ1_25: J1.25 R12.1
NetJ1_27: J1.27 R18.2
NetJ1_28: J1.28 R22.1
NetJ1_29: J1.29 R19.2
NetJ1_30: J1.30 R24.1
NetJ1_31: J1.31 R20.2
NetJ1_33: J1.33 R21.2
NetJ1_34: J1.34 R30.1
NetJ1_35: J1.35 R23.2
NetJ1_36: J1.36 R32.1
NetJ1_37: J1.37 R26.2
NetJ1_39: J1.39 R27.2
NetJ1_40: J1.40 R33.1
NetJ1_41: J1.41 R28.2
NetJ1_42: J1.42 R35.1
NetJ1_43: J1.43 R60.1
NetJ1_45: J1.45 R61.1
NetJ1_46: J1.46 R39.1
NetJ1_47: J1.47 R62.1
NetJ1_48: J1.48 R41.1
NetJ1_49: J1.49 R63.1
NetJ1_51: J1.51 R64.1
NetJ1_52: J1.52 R58.1
NetJ1_53: J1.53 R34.2
NetJ1_54: J1.54 R59.1
NetJ1_55: J1.55 R37.2
NetJ1_56: J1.56 R65.2
NetJ1_57: J1.57 R38.2
NetJ1_58: J1.58 R66.1
NetJ1_59: J1.59 R40.2
NetJ1_60: J1.60 R67.1
NetJ2_21: J2.21 R137.1
NetJ2_23: J2.23 R136.1
NetJ2_27: J2.27 R135.1
NetJ2_29: J2.29 R134.1
NetJ2_34: J2.34 R132.2
NetJ2_36: J2.36 R130.2
NetJ2_38: J2.38 R129.2
NetJ2_39: J2.39 R133.1
NetJ2_40: J2.40 R128.2
NetJ2_41: J2.41 R131.1
NetJ2_42: J2.42 R127.2
NetJ2_44: J2.44 R126.2
NetJ2_46: J2.46 R125.2
NetJ2_48: J2.48 R124.2
NetJ2_50: J2.50 R140.2

Not connected (* = marked no-connect by the designer): J2 1* 2* 3* 4* 5* 6* 7* 8* 9* 10* 11* 12* 13* 14* 15* 16* 17* 18* 20* 22* 24* 26* 33* 35* 45* 47* 49* 51* 53* 55*

### Notes on the sheet
- CONNECTORS
- 60 PIN HD CONNECTOR
- 60 PIN HD CONNECTOR FOR xWRxxxx DEVICES COMPATABILITY

### Library data of the parts
J1 J2 = CMP-0075524-1: Receptacle, 0.5 mm, 30x2, Gold, TH; Manufacturer: Samtec; Pitch_mm: 0.5; Gender: Female; Green_REACh: Passed; CT: False; Shrouded: N; RowSpacing_mm: 5.73; Green_Lifecycle: Active; Row_Count: 2
R4-R13 R16 R22 R24 R30-R42 R58-R67 R131 R133-R137 R140 = CMP-0027008-4: RES, 0, 5%, 0.05 W, 0201; Manufacturer: Vishay-Dale; Power_W: 50mW; TempCo: ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; Value2: 0.05W; SizeArea_mm2: 0.18; AEC Qualified: N; AEC Category: Q200
R15 R17-R21 R23 R26-R28 R124-R130 R132 = CMP-0078192-2: RES, 20.0, 1%, 0.05 W, 0201; Manufacturer: Vishay-Dale; Value_Code: 20R0; SizeArea_mm2: 0.18; AEC Qualified: N; AEC Category: Q200; Res_ohm: 20; Value: 20.0; SizeZ_mm: 0.33; EIA_Code: E96; TempCo: 200 ppm/C; Power_W: 50mW; VDC_V: 30V; SizeY_mm: 0.3; Value2: 0.05W; SizeX_mm: 0.6
R52 R53 = CMP-0025958-3: RES, 10.0 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 10k0; Value: 10.0k; EIA_Code: E96; Res_ohm: 10k; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
TP14 = CMP-0055138-1: Test Point, Miniature, Black, TH; Manufacturer: Keystone; CNHeader: FALSE; Green_Lifecycle: Active; Green_REACh: Passed; ContactFinish: Silver; CT: TRUE

## Sheet PROC073C_Temp_Current_sensor.SchDoc: Temp Current sonsor
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 8; Revision: Use project parameter SCH_Rev; SheetNumber: 8; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C36  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
C57  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
C58  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
C59  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
C63  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
C65  ValueDisplayed: 0.1uF  [0402L]  (hidden comment: CGA2B3X7R1H104K050BB)
R2  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R14  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R25  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R29  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R54  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R55  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R56  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R57  Res_ohm: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R94  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R101  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R103  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R104  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R105  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R106  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R107  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R108  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R109  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R110  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R111  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R112  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R113  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R114  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R115  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R116  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R117  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R139  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R142  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R143  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R144  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R145  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R146  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R147  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R151  Res_ohm: 0  [0402]  (hidden comment: CRCW04020000Z0ED)
R157  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R158  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R159  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R160  ValueDisplayed: 0  [0201]  (hidden comment: CRCW02010000Z0ED)
R161  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R162  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
U3  TMP112AQDRLRQ1  [DRL0006A]
U6  INA226AIDGST  [DGS0010A_L]
U7  INA226AIDGST  [DGS0010A_L]
U8  INA226AIDGST  [DGS0010A_L]
U10  INA226AIDGST  [DGS0010A_L]
U11  CAT24C08WI-GT3  [SOIC-8]

### Blocks framed on the sheet
CURRENT SENSOR: C57-C59 C63 R2 R14 R25 R29 R94 R101 R103-R117 R139 R142-R147 U6-U8 U10
TEMPERATURE SENSOR: C36 R54-R57 R151 U3
EEPROM: C65 R157-R162 U11

### Ports
1V0_VIN+ (in), 1V0_VIN- (in), 1V2_VIN+ (in), 1V2_VIN- (in), 1V8_VIN+ (in), 1V8_VIN- (in), 3V3_VIN+ (in), 3V3_VIN- (in), RADAR_SCL, RADAR_SDA

### Nets
CB_PMIC_1V0: U7.9(VIN-) ; port 1V0_VIN-
CB_PMIC_1V2: U8.9(VIN-) ; port 1V2_VIN-
CB_PMIC_1V8: U6.9(VIN-) ; port 1V8_VIN-
GND: C36.1 C57.1 C58.1 C59.1 C63.1 C65.1 R57.2 R101.1 R103.1 R113.1 R114.1 R116.1 R117.1 R146.1 R147.1 R158.1 R162.1 U3.2(GND) U6.7(GND) U7.7(GND) U8.7(GND) U10.7(GND) U11.4(VSS)
PMIC_1V0: U7.8(VBUS) U7.10(VIN+) ; port 1V0_VIN+
PMIC_1V2: U8.8(VBUS) U8.10(VIN+) ; port 1V2_VIN+
PMIC_1V8: U6.8(VBUS) U6.10(VIN+) ; port 1V8_VIN+
RADAR_3V3: U10.9(VIN-) ; port 3V3_VIN-
VCC_3V3: C36.2 C57.2 C58.2 C59.2 C63.2 C65.2 R2.2 R14.2 R54.2 R94.1 R104.2 R105.2 R106.2 R107.2 R112.1 R115.1 R139.2 R142.2 R145.1 R157.2 R161.2 U3.5(V+) U6.6(VS+) U7.6(VS+) U8.6(VS+) U10.6(VS+) U11.8(VCC)
VCC_LD_SW_3V3: U10.8(VBUS) U10.10(VIN+) ; port 3V3_VIN+
A2: R161.1 R162.2 U11.3(A2)
RADAR_SCL: R25.2 R56.1 R108.2 R109.2 R143.2 R159.2 ; port RADAR_SCL
RADAR_SDA: R29.2 R55.1 R110.2 R111.2 R144.2 R160.2 ; port RADAR_SDA
WP#: R157.1 R158.2 U11.7(WP)
NetR2_1: R2.1 R101.2 U6.2(A0)
NetR14_1: R14.1 R103.2 U6.1(A1)
NetR25_1: R25.1 U6.5(SCL)
NetR29_1: R29.1 U6.4(SDA)
NetR54_1: R54.1 U3.3(ALERT)
NetR55_2: R55.2 U3.6(SDA)
NetR56_2: R56.2 R151.1 U3.1(SCL)
NetR57_1: R57.1 R151.2 U3.4(ADD0)
NetR94_2: R94.2 U6.3(ALERT)
NetR104_1: R104.1 R113.2 U7.2(A0)
NetR105_1: R105.1 R114.2 U7.1(A1)
NetR106_1: R106.1 R116.2 U8.2(A0)
NetR107_1: R107.1 R117.2 U8.1(A1)
NetR108_1: R108.1 U7.5(SCL)
NetR109_1: R109.1 U8.5(SCL)
NetR110_1: R110.1 U7.4(SDA)
NetR111_1: R111.1 U8.4(SDA)
NetR112_2: R112.2 U7.3(ALERT)
NetR115_2: R115.2 U8.3(ALERT)
NetR139_1: R139.1 R146.2 U10.2(A0)
NetR142_1: R142.1 R147.2 U10.1(A1)
NetR143_1: R143.1 U10.5(SCL)
NetR144_1: R144.1 U10.4(SDA)
NetR145_2: R145.2 U10.3(ALERT)
NetR159_1: R159.1 U11.6(SCL)
NetR160_1: R160.1 U11.5(SDA)

Not connected (* = marked no-connect by the designer): U11 1(NC)* 2(NC)*

### Notes on the sheet
- I2C Address : 1000 000
- I2C Address : 1000 101
- (near R151) I2C Address : 1001 011
- I2C Address : 1010 0XX
- I2C Address : 1000 001
- I2C Address : 1000 100

### Library data of the parts
C36 C57-C59 C63 C65 = CMP-0006325-2: CAP, CERM, 0.1 uF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: TDK; TaMin_C: -55°C; ESR_ohm: 0.039064; Polarized: N; SizeAreaWB_mm2: 3; Value1: 0.039064 ohm; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Value2: 50V; AEC Qualified: Y; Cap_F: 100nF; IRMS_A: 8.14669dA; AEC Category: Q200
R2 R14 R54 R94 R101 R103-R107 R112-R117 R139 R142 R145-R147 R157 R158 R161 R162 = CMP-0025958-3: as R52 on sheet PROC073C_HD_Connector_60Pin
R25 R29 R55 R56 R108-R111 R143 R144 R159 R160 = CMP-0027008-4: as R4 on sheet PROC073C_HD_Connector_60Pin
R57 = CMP-0026822-3: RES, 0, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; INSTALLATION: DNP
R151 = CMP-0026822-3: RES, 0, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200
U3 = CMP-0067398-2: Automotive Grade, 1.4V-Capable +/-0.5degC Temperature Sensor with Alert Function and I2C/SMBus, DRL0006A (SOT-OTHER-6); Manufacturer: Texas Instruments; SizeZ_mm: 0.6; SizeX_mm: 1.6; SizeArea_mm2: 2.56; CompType: IC; U/M: EA; SizeAreaWB_mm2: 6.76
U6-U8 U10 = CMP-0037978-1: High-Side Measurement, Bi-Directional Current / Power Monitor with I2C Interface, 2.7 to 5.5 V, -40 to 125 degC, 10-pin SOP (DGS10), Green (RoHS & no Sb/Br); Vs(Min)(V): 2.7; Rating: Catalog; Quiescent Current (+/-)(Typ)(mA): 0.33; Input Offset (+/-)(Max)(uV): 10; CMRR(Min)(dB): 126; Vs(Max)(V): 5.5; Common Mode Range(Max)(V): 36; Input Offset Drift (+/-)(Max)(uV/Degrees Celsius): 0.1; Common Mode Range(Min)(V): 0; SubFamily: Current Shunt Monitor; Gain(V/V): 1; Small-Signal Bandwidth(Typ)(MHz): 0.007
U11 = CMP-0005309-2: IC, EEPROM, 8KBIT, 400KHZ, 8SOIC; Manufacturer: ON Semiconductor; SizeAreaWB_mm2: 55.131; SizeZ_mm: 1.75; SizeX_mm: 5.99; SizeY_mm: 4.9; SizeArea_mm2: 29.351

## Sheet PROC073C_Flash_USB_To_UART.SchDoc: Flash USB to UART
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 9; Revision: Use project parameter SCH_Rev; SheetNumber: 9; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C44  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C45  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C46  value 10uF  [0402_070]  (hidden comment: CL05A106MP5NUNC)
C47  value 10uF  [0402_070]  (hidden comment: CL05A106MP5NUNC)
C48  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C49  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C50  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C51  Cap_F: 1µF  [FP-CL03A105MO3NRNH_0201-IPC_C]  (hidden comment: CL03A105MO3NRNH)
D1  value 30V  [DSN2_0603]  (hidden comment: NSR20F30NXT5G)
D2  value 30V  [DSN2_0603]  (hidden comment: NSR20F30NXT5G)
D4  Color: Green  [APHHS1005_Green]  (hidden comment: APHHS1005CGCK)
J5  105017-0001  [CONN_105017-0001]
L9  BLM15PD300SZ1D  [0402L]  (value not drawn)
L10  BLM15PD300SZ1D  [0402L]  (value not drawn)
R90  value 4.99k  [0201L]  (hidden comment: RC0201FR-074K99L)
R91  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-MFG]  (hidden comment: RC0201JR-070RL)
R92  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-MFG]  (hidden comment: RC0201JR-070RL)
R93  value 4.99k  [0201L]  (hidden comment: RC0201FR-074K99L)
R95  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R96  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-MFG]  (hidden comment: RC0201JR-070RL)
R97  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-MFG]  (hidden comment: RC0201JR-070RL)
R98  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-MFG]  (hidden comment: RC0201JR-070RL)
R99  value 220  [0201L]  (hidden comment: RC0201JR-07220RL)
R100  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R102  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R118  value 510  [0201L]  (hidden comment: RC0201JR-07510RL)
R119  value 100k  [0201L]  (hidden comment: CRCW0201100KFKED)
R120  value 100k  [0201L]  (hidden comment: CRCW0201100KFKED)
R121  Res_ohm: 200  [FP-CRCW0402200RFKEDHP_0402-IPC_C]  (hidden comment: CRCW0402200RFKEDHP)
TP1  TESTPOINT  [TP_25MIL-SMT]  (value not drawn)  (no BOM)
TP8  TESTPOINT  [TP_25MIL-SMT]  (value not drawn)  (no BOM)
U14  CP2105-F01-GMR  [FP-CP2105-F01-GMR_QFN24-EP-IPC_A]
U15  TS5A23157RSER  [RSE0010A]
U16  TPS2115ADRBR  [DRB0008B]

### Ports
CONN_RS232RX (bidir), CONN_RS232TX (bidir), MUX_IN_2 (in), RADAR_MSS_LOGGER (bidir), RADAR_RS232RX (bidir), RADAR_RS232TX (bidir), USB_AR_RS232RX (bidir), USB_AR_RS232TX (bidir)

### Nets
5V_IN: D2.1(K) R90.1
5V_IN_SW: C51.1 L10.1 R118.1 U16.7(OUT)
5V_IN_USB: C46.2 C47.1 C49.1 D1.1(K) U16.6(IN2)
CONN_5V: C50.1 R102.1 U16.8(IN1)
GND: C44.1 C45.1 C46.1 C47.2 C48.2 C49.2 C50.2 C51.2 J5.5 J5.6 J5.7 J5.8 J5.9 J5.10 J5.11 R95.1 R99.1 R119.2 R120.1 R121.1 U14.2(GND) U14.25(GND) U15.3(GND) U16.5(GND) U16.9(EP)
PMICOUT_3V3: C44.2 C45.2 C48.1 R93.1 R100.2 U14.5(VIO) U14.6(VDD) U14.7(REGIN) U15.8(V+)
USB_5V: J5.1 L9.1
CONN_RS232RX: U15.7(NC2) ; port CONN_RS232RX
CONN_RS232TX: U15.9(NC1) ; port CONN_RS232TX
MUX_IN_2: R100.1 U15.1(IN1) U15.5(IN2) ; port MUX_IN_2
RADAR_MSS_LOGGER: R96.2 ; port RADAR_MSS_LOGGER
RADAR_RS232RX: U15.6(COM2) ; port RADAR_RS232RX
RADAR_RS232TX: U15.10(COM1) ; port RADAR_RS232TX
USB_AR_RS232RX: R98.1 U15.4(NO2) ; port USB_AR_RS232RX
USB_AR_RS232TX: R97.2 U15.2(NO1) ; port USB_AR_RS232TX
USB_DM: J5.2 R92.2
USB_DP: J5.3 R91.2
VBUS: R90.2 R95.2 U14.8(VBUS)
NetD1_2: D1.2(A) L9.2
NetD2_2: D2.2(A) L10.2
NetD4_1: D4.1(A) U14.17(~{SUSPEND}/~{RI_ECI})
NetD4_2: D4.2(K) R99.2
NetR91_1: R91.1 U14.3(D+)
NetR92_1: R92.1 U14.4(D-)
NetR93_2: R93.2 U14.9(~{RST})
NetR96_1: R96.1 U14.20(RXD_SCI)
NetR97_1: R97.1 U14.12(RXD_ECI)
NetR98_2: R98.2 U14.13(TXD_ECI)
NetR102_2: R102.2 R120.2 U16.3(D1)
NetR118_2: R118.2 TP8.1 U16.1(STAT)
NetR119_1: R119.1 U16.2(D0)
NetR121_2: R121.2 U16.4(ILIM)
NetTP1_1: TP1.1 U14.1(~{SUSPEND}/~{RI_SCI})

Not connected (* = marked no-connect by the designer): J5 4*; U14 10(~{CTS_ECI})* 11(~{RTS_ECI})* 14(GPIO.1_ECI/~{DSR_ECI})* 15(GPIO.0_ECI/~{DTR_ECI})* 16(NC/~{DCD_ECI}/VPP)* 18(~{CTS_SCI})* 19(~{RTS_SCI})* 21(TXD_SCI)* 22(GPIO.2_SCI/~{DSR_SCI})* 23(GPIO.1_SCI/~{DTR_SCI})* 24(GPIO.0_SCI/~{DCD_SCI})*

### Notes on the sheet
- USB CONNECTOR
- USB to UART
- (near U14) NOTE: USB SELF POWERED CONFIGURATION
- USB ENUMERATION LED
- CONNECTOR PWR / USB PWR LOAD SWITCH
- UART SELECTION
- S1.1 ON  : BREAK AWAY UART
- S1.1 OFF : MAIN BOARD UART
- MUX IN CONFIG

### Library data of the parts
C44 C45 C48-C50 = CMP-0086440-1: Cap Ceramic 0.1uF 35V X5R 10% Pad SMD 0201 85C T/R; Manufacturer: Murata Electronics North America; AEC Qualified: No; SizeZ_mm: 0.33mm; Symbol Name: SYM-GRM033R6YA104KE14D; TempCo: 15%
C46 C47 = CMP-0006339-4: CAP, CERM, 10 uF, 10 V, +/- 20%, X5R, 0402; Manufacturer: Samsung Electro-Mechanics; AEC Category: Q200; AEC Qualified: N; Cap_Case: 0402; Cap_F: 10µF; SizeArea_mm2: 0.5; SizeAreaWB_mm2: 3; SizeX_mm: 1; SizeZ_mm: 0.6; TaMax_C: 85°C; TaMin_C: -55°C; U/M: EA; Value1: Unknown; Value2: 10V
C51 = CMP-0086446-1: 1µF ±20% 16V Ceramic Capacitor X5R 0201; Manufacturer: Samsung Electro-Mechanics; AEC Qualified: No; SizeZ_mm: 0.39mm; Symbol Name: SYM-CL03A105MO3NRNH; TempCo: 15%
D1 D2 = CMP-0028829-2: Diode, Schottky, 30 V, 2 A, 2-XFDFN; Manufacturer: ON Semiconductor; Value2: 0.48V; SizeY_mm: 0.8; TJmax_C: 150°C; Green_Lifecycle: Not Set; SizeAreaWB_mm2: 4.68; Value1: 2A; SizeArea_mm2: 1.28; Green_REACh: Incomplete; AEC Category: Q101; SizeZ_mm: 0.31; Vf_V: 480mV; AEC Qualified: N; SizeX_mm: 1.6
D4 = CMP-0067682-2: LED, Green, SMD; Manufacturer: Kingbright; Angle: 120.0; Power_TotalModule: 75mW; SizeZ_mm: 0.6; Vf_V: 2.1V; Vr_V: 5V; Io_A: 20mA; Ir_A: 10µA; SizeArea_mm2: 0.5; SizeAreaWB_mm2: 3.0; SizeX_mm: 1.0; Tjmax_C: 85°C; Value1: 0.075W
J5 = CMP-0055293-1: Connector, Receptacle, Micro-USB Type B, R/A, Bottom Mount SMT; Manufacturer: Molex; CNHeader: FALSE; CompType: USB; CT: TRUE; Gender: Female; Green_Lifecycle: Active; Green_REACh: Passed
L9 L10 = CMP-0078934-1: Inductor, Ferrite Bead, Ferrite, 2.2 A, 0.035 ohm, AEC-Q200 Grade 1, SMD; Manufacturer: MuRata; AEC Category: Q200; AEC Grade: 1; AEC Qualified: Y; DCR_ohm: 0.035; Imax_A: 2.2A; SizeArea_mm2: 0.5; SizeAreaWB_mm2: 3; SizeZ_mm: 0.6
R90 R93 = CMP-0027745-1: RES, 4.99 k, 1%, 0.05 W, 0201; Manufacturer: Yageo America; AEC Category: Q200; AEC Qualified: N; EIA_Code: E96; Power_W: 50mW; SizeArea_mm2: 0.18; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; TempCo: 200 ppm/C; U/M: EA; Value2: 0.05W; Value_Code: 4k99; VDC_V: 25V
R91 R92 R96-R98 = CMP-0086442-2: RES SMD 0 OHM JUMPER 1/20W 0201; Manufacturer: Yageo; AEC Qualified: No; Power_W: 50mW; SizeZ_mm: 0.26mm; TempCo: 200ppm/°C; Tolerance_%: 5%; VDC_V: 25V
R95 R100 R102 = CMP-0088002-1: 10 kOhms ±0.5% 0.05W, 1/20W Chip Resistor 0201 (0603 Metric)  Thin Film; Manufacturer: Susumu; AEC Qualified: No; Power_W: 50mW; SizeZ_mm: 0.26mm; Symbol Name: SYM-RR0306P-103-D; TempCo: 25ppm/°C; VDC_V: 15V
R99 = CMP-0027072-1: RES, 220, 5%, 0.05 W, 0201; Manufacturer: Yageo America; AEC Category: Q200; AEC Qualified: N; EIA_Code: E24; Power_W: 50mW; SizeArea_mm2: 0.18; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; TempCo: 200 ppm/C; U/M: EA; Value2: 0.05W; Value_Code: 220R; VDC_V: 25V
R118 = CMP-0027137-1: RES, 510, 5%, 0.05 W, 0201; Manufacturer: Yageo America; AEC Category: Q200; AEC Qualified: N; EIA_Code: E24; Power_W: 50mW; SizeArea_mm2: 0.18; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; TempCo: 200 ppm/C; U/M: EA; Value2: 0.05W; Value_Code: 510R; VDC_V: 25V
R119 R120 = CMP-0027261-3: RES, 100 k, 1%, 0.05 W, 0201; Manufacturer: Vishay-Dale; AEC Category: Q200; AEC Qualified: N; EIA_Code: E96; Power_W: 50mW; SizeArea_mm2: 0.18; SizeX_mm: 0.6; SizeY_mm: 0.3; SizeZ_mm: 0.26; TempCo: 100 ppm/C; Value2: 0.05W; VDC_V: 30V
R121 = CMP-0087183-1: RES SMD 200 OHM 1% 1/5W 0402; Manufacturer: Vishay Dale; AEC Grade: Grade 0; AEC Qualified: Yes; Power_W: 200mW; SizeZ_mm: 0.4mm; Symbol Name: SYM-CRCW0402200RFKEDHP; TempCo: 100ppm/°C; VDC_V: 50V
TP1 TP8 = CMP-0078143-3: TEST POINT.  No entry in BOM.
U14 = CMP-0087172-1: I/O Controller Interface IC USB to Dual UART bridge; Manufacturer: Silicon Labs; SizeZ_mm: 0.8mm
U15 = CMP-0074545-1: Dual 10-ohm SPDT Analog Switch, RSE0010A (UQFN-10); Alternate Manufacturer: Texas Instruments; CompType: IC; SizeArea_mm2: 3.0; SizeAreaWB_mm2: 7.5; SizeX_mm: 1.5; SizeY_mm: 2.0; SizeZ_mm: 0.6; U/M: EA
U16 = CMP-0043358-3: Dual In / Single Out Autoswitching Power Mux, 2.8 to 5.5 V, -40 to 85 degC, 8-pin SON (DRB), Green (RoHS & no Sb/Br); Manufacturer: Texas Instruments; AEC Category: Q200; AEC Qualified: N; CompType: IC; IN1, IN2 Input Voltage(Max)(V): 5.5; IN1, IN2 Input Voltage(Min)(V): 2.8; IN1 Output Current(Max)(A): 1.25; IN1 rDS(on)(Typ)(mOhm): 84; IN2 rDS(on)(Typ)(Ohms): 0.084; Number of Inputs: 2; SizeArea_mm2: 9.0; SizeAreaWB_mm2: 16.0; SizeX_mm: 3.0; SizeZ_mm: 1.0; SubFamily: Power Multiplexer (MUX)

## Sheet PROC073C_HD_DCA_Conn.SchDoc: HD DCA Connector
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 10; Revision: Use project parameter SCH_Rev; SheetNumber: 10; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C52  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
C53  Cap_F: 100nF  [FP-GRM033R6YA104KE14D_0201 (0603 Metric)-IPC_C]  (hidden comment: GRM033R6YA104KE14D)
D5  Color: Green  [APHHS1005_Green]  (hidden comment: APHHS1005CGCK)
D7  Color: Green  [APHHS1005_Green]  (hidden comment: APHHS1005CGCK)
J6  QSH-030-01-L-D-A  [Samtec_QSH-030-01-X-D-A]  (value not drawn)
Q1  BSS123-7-F  [FP-BSS123-7-F_SOT23-IPC_C]
R122  ValueDisplayed: 0  [0402L]  (hidden comment: ERJ-2GE0R00X)
R123  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R138  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R141  value 510  [0201L]  (hidden comment: RC0201JR-07510RL)
R148  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R149  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R163  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R164  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R165  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R166  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R167  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R168  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R170  ValueDisplayed: 20.0  [0201_033]  (hidden comment: CRCW020120R0FNED)
R171  value 510  [0201L]  (hidden comment: RC0201JR-07510RL)
R212  value 220  [0201L]  (hidden comment: RC0201JR-07220RL)
R213  value 220  [0201L]  (hidden comment: RC0201JR-07220RL)
R214  Res_ohm: 0  [FP-RC0201JR-070RL_0201 (0603 Metric)-IPC_C]  (hidden comment: RC0201JR-070RL)
R215  Res_ohm: 10k  [FP-RR0306P-103-D_0201-IPC_C]  (hidden comment: RR0306P-103-D)
R217  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R218  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R219  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R220  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R221  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R222  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R223  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R224  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R225  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R226  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R227  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R228  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R229  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R230  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
S2  B3U-1000P  [SW_B3U-1000P]
S3  B3U-1000P  [SW_B3U-1000P]
TP12  5001  [Keystone5001]  (value not drawn)
TP13  5001  [Keystone5001]  (value not drawn)
U17  SN74LVC1G11DSFR  [DSF0006A]  (parts A,B of 2)

### Ports
CONN_RS232RX, CONN_RS232TX, PGOOD, RADAR_DMM_CLK, RADAR_DMM_SYNC, RADAR_DP0, RADAR_DP1, RADAR_DP2, RADAR_DP3, RADAR_DP4, RADAR_DP5, RADAR_DP6, RADAR_DP7, RADAR_DP8, RADAR_DP9, RADAR_DP10, RADAR_DP11, RADAR_DP12, RADAR_DP13, RADAR_DP14, RADAR_DP15, RADAR_GPIO_1 (bidir), RADAR_GPIO_2 (bidir), RADAR_HOSTINTR1, RADAR_LVDS_0M, RADAR_LVDS_0P, RADAR_LVDS_1M, RADAR_LVDS_1P, RADAR_LVDS_2M, RADAR_LVDS_2P, RADAR_LVDS_3M, RADAR_LVDS_3P, RADAR_LVDS_CLKM, RADAR_LVDS_CLKP, RADAR_LVDS_FRCLKM, RADAR_LVDS_FRCLKP, RADAR_LVDS_VALIDM, RADAR_LVDS_VALIDP, RADAR_NRST (out), RADAR_NRST_1, RADAR_NRST_1 (in), RADAR_NRST_2 (in), RADAR_NRST_2 (out), RADAR_SCL, RADAR_SDA, RADAR_SYNC_IN, SPI_CLK1, SPI_CS1, SPI_MISO1, SPI_MOSI1

### Nets
5V_IN: R141.1
CONN_5V: R122.1 TP13.1
GND: C52.1 C53.2 J6.18 J6.24 J6.30 J6.36 J6.42 J6.48 J6.54 J6.60 J6.MP1 J6.MP2 J6.MP3 J6.MP4 Q1.2(S) R212.2 R215.1 S2.2 TP12.1 U17.2(GND)
VCC_3V3: C52.2 R123.1 R138.1 R165.2 R213.2 U17.5(VCC)
CONN_RS232RX: J6.55 ; port CONN_RS232RX
CONN_RS232TX: J6.57 ; port CONN_RS232TX
PGOOD: J6.13 ; port PGOOD
RADAR_DMM_CLK: J6.15 ; port RADAR_DMM_CLK
RADAR_DMM_SYNC: J6.17 ; port RADAR_DMM_SYNC
RADAR_DP0: J6.19 ; port RADAR_DP0
RADAR_DP1: J6.21 ; port RADAR_DP1
RADAR_DP2: J6.23 ; port RADAR_DP2
RADAR_DP3: J6.25 ; port RADAR_DP3
RADAR_DP4: J6.27 ; port RADAR_DP4
RADAR_DP5: J6.29 ; port RADAR_DP5
RADAR_DP6: J6.31 ; port RADAR_DP6
RADAR_DP7: J6.33 ; port RADAR_DP7
RADAR_DP8: R148.1 ; port RADAR_DP8
RADAR_DP9: R149.1 ; port RADAR_DP9
RADAR_DP10: R163.1 ; port RADAR_DP10
RADAR_DP11: R164.1 ; port RADAR_DP11
RADAR_DP12: R166.1 ; port RADAR_DP12
RADAR_DP13: R167.1 ; port RADAR_DP13
RADAR_DP14: R168.1 ; port RADAR_DP14
RADAR_DP15: R170.1 ; port RADAR_DP15
RADAR_GPIO_1: R214.2 ; port RADAR_GPIO_1
RADAR_GPIO_2: D7.1(A) ; port RADAR_GPIO_2
RADAR_HOSTINTR1: J6.10 ; port RADAR_HOSTINTR1
RADAR_LVDS_0M: R230.2 ; port RADAR_LVDS_0M
RADAR_LVDS_0P: R229.2 ; port RADAR_LVDS_0P
RADAR_LVDS_1M: R228.2 ; port RADAR_LVDS_1M
RADAR_LVDS_1P: R227.2 ; port RADAR_LVDS_1P
RADAR_LVDS_2M: R224.2 ; port RADAR_LVDS_2M
RADAR_LVDS_2P: R223.2 ; port RADAR_LVDS_2P
RADAR_LVDS_3M: R222.2 ; port RADAR_LVDS_3M
RADAR_LVDS_3P: R221.2 ; port RADAR_LVDS_3P
RADAR_LVDS_CLKM: R226.2 ; port RADAR_LVDS_CLKM
RADAR_LVDS_CLKP: R225.2 ; port RADAR_LVDS_CLKP
RADAR_LVDS_FRCLKM: R220.2 ; port RADAR_LVDS_FRCLKM
RADAR_LVDS_FRCLKP: R219.2 ; port RADAR_LVDS_FRCLKP
RADAR_LVDS_VALIDM: R218.2 ; port RADAR_LVDS_VALIDM
RADAR_LVDS_VALIDP: R217.2 ; port RADAR_LVDS_VALIDP
RADAR_NRST: R171.1 U17.4(Y) ; port RADAR_NRST
RADAR_NRST_1: J6.59 R123.2 U17.1(A) ; port RADAR_NRST_1
RADAR_NRST_2: C53.1 R165.1 S2.1 U17.6(C) ; port RADAR_NRST_2
RADAR_SCL: J6.53 ; port RADAR_SCL
RADAR_SDA: J6.51 ; port RADAR_SDA
RADAR_SYNC_IN: J6.16 ; port RADAR_SYNC_IN
SPI_CLK1: J6.9 ; port SPI_CLK1
SPI_CS1: J6.7 ; port SPI_CS1
SPI_MISO1: J6.12 ; port SPI_MISO1
SPI_MOSI1: J6.11 ; port SPI_MOSI1
NetD5_1: D5.1(A) R141.2
NetD5_2: D5.2(K) Q1.3(D)
NetD7_2: D7.2(K) R212.1
NetJ6_1: J6.1 J6.2 J6.3 R122.2
NetJ6_20: J6.20 R217.1
NetJ6_22: J6.22 R218.1
NetJ6_26: J6.26 R219.1
NetJ6_28: J6.28 R220.1
NetJ6_32: J6.32 R221.1
NetJ6_34: J6.34 R222.1
NetJ6_35: J6.35 R148.2
NetJ6_37: J6.37 R149.2
NetJ6_38: J6.38 R223.1
NetJ6_39: J6.39 R163.2
NetJ6_40: J6.40 R224.1
NetJ6_41: J6.41 R164.2
NetJ6_43: J6.43 R166.2
NetJ6_44: J6.44 R225.1
NetJ6_45: J6.45 R167.2
NetJ6_46: J6.46 R226.1
NetJ6_47: J6.47 R168.2
NetJ6_49: J6.49 R170.2
NetJ6_50: J6.50 R227.1
NetJ6_52: J6.52 R228.1
NetJ6_56: J6.56 R229.1
NetJ6_58: J6.58 R230.1
NetQ1_1: Q1.1(G) R171.2
NetR138_2: R138.2 U17.3(B)
NetR213_1: R213.1 S3.2
NetR214_1: R214.1 R215.2 S3.1

Not connected (* = marked no-connect by the designer): J6 4* 5* 6* 8* 14*

### Notes on the sheet
- 60PIN HD CONNECTOR FOR DCA1000
- RESET,  USER LED and SWITCHES
- RESET
- USER LED
- (near S3) USER SWITCH
- RESET SWITCH

### Library data of the parts
C52 C53 = CMP-0086440-1: as C44 on sheet PROC073C_Flash_USB_To_UART
D5 D7 = CMP-0067682-2: as D4 on sheet PROC073C_Flash_USB_To_UART
J6 = CMP-0075524-1: as J1 on sheet PROC073C_HD_Connector_60Pin
Q1 = CMP-0087176-1: MOSFET N-CH 100V 170MA SOT23-3; Manufacturer: Diodes Incorporated; AEC Qualified: No; ChMode: False; Rdson45_ohm: 6; SizeZ_mm: 1.1mm; Vgs_V: 20V
R122 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 600 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; SizeAreaWB_mm2: 3
R123 R138 R165 R215 = CMP-0088002-1: as R95 on sheet PROC073C_Flash_USB_To_UART
R141 R171 = CMP-0027137-1: as R118 on sheet PROC073C_Flash_USB_To_UART
R148 R149 R163 R164 R166-R168 R170 = CMP-0078192-2: as R15 on sheet PROC073C_HD_Connector_60Pin
R212 R213 = CMP-0027072-1: as R99 on sheet PROC073C_Flash_USB_To_UART
R214 = CMP-0086442-2: as R91 on sheet PROC073C_Flash_USB_To_UART
R217-R230 = CMP-0027008-4: as R4 on sheet PROC073C_HD_Connector_60Pin
S2 S3 = CMP-0002150-2: SWITCH TACTILE SPST-NO 0.05A 12V; Manufacturer: Omron Electronic Components; CurrentRating_mA: 50A; PositionCount: 1; SwitchFunction: Off-Mom
TP12 TP13 = CMP-0055138-1: as TP14 on sheet PROC073C_HD_Connector_60Pin
U17 = CMP-0051215-4: Single 3-Input Positive-AND Gate, DSF0006A, LARGE T&R; Manufacturer: Texas Instruments; Output Type: CMOS; Bits(#): 1; Input Type: CMOS/TTL; Technology Family: LVC; Schmitt Trigger: No; VCC(Max)(V): 5.5; Gate Type: AND; Rating: Catalog; Output Drive (IOL/IOH)(Max)(mA): 32/-32; ICC @ Nom Voltage(Max)(mA): 0.01; VCC(Min)(V): 1.65; F @ Nom Voltage(Max)(Mhz): 150; Logic: True; Voltage(Nom)(V): 1.8,2.5,3.3,5; tpd @ Nom Voltage(Max)(ns): 20,7.8,6.2,4.6

## Sheet PROC073C_SOP_Ctrl.SchDoc: SOP Control
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 11; Revision: Use project parameter SCH_Rev; SheetNumber: 11; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
R202  ValueDisplayed: 0  [0402L]  (hidden comment: ERJ-2GE0R00X)
R203  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R204  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R205  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)
R206  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R207  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R208  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)
R209  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R210  ValueDisplayed: 7.87k  [0402L]  (hidden comment: CRCW04027K87FKED)
R211  ValueDisplayed: 82.5k  [0402L]  (hidden comment: CRCW040282K5FKED)
S1  218-6LPST  [SW_218-6LPST]  (value not drawn)

### Ports
MUX_IN_1 (in), MUX_IN_2 (in), PMIC_CLK, RADAR_PMIC_CLKOUT_SOP2, RADAR_SYNC_OUT_SOP1, RADAR_TDO_SOP0

### Nets
GND: R205.1 R208.1 R211.1 S1.8(5A) S1.9(4A)
PMICOUT_3V3: S1.10(3A) S1.11(2A) S1.12(1A)
MUX_IN_1: S1.4 ; port MUX_IN_1
MUX_IN_2: S1.5 ; port MUX_IN_2
PMIC_CLK: R202.2 ; port PMIC_CLK
RADAR_PMIC_CLKOUT_SOP2: R202.1 R203.1 ; port RADAR_PMIC_CLKOUT_SOP2
RADAR_SYNC_OUT_SOP1: R206.1 ; port RADAR_SYNC_OUT_SOP1
RADAR_TDO_SOP0: R209.1 ; port RADAR_TDO_SOP0
NetR203_2: R203.2 R204.1 R205.2
NetR204_2: R204.2 S1.1
NetR206_2: R206.2 R207.1 R208.2
NetR207_2: R207.2 S1.2
NetR209_2: R209.2 R210.1 R211.2
NetR210_2: R210.2 S1.3

Not connected (* = marked no-connect by the designer): S1 6* 7(6A)*

### Library data of the parts
R202 = CMP-0026992-3: as R122 on sheet PROC073C_HD_DCA_Conn
R203 R206 R209 = CMP-0025958-3: as R52 on sheet PROC073C_HD_Connector_60Pin
R204 R207 R210 = CMP-0026557-2: RES, 7.87 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 7k87; Value: 7.87k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
R205 R208 R211 = CMP-0026574-2: RES, 82.5 k, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 82k5; Value: 82.5k; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Grade: 0; AEC Category: Q200
S1 = CMP-0002304-1: Switch, SPST, Slide, Off-On, 6 Pos, 0.025A, 24V, SMD; Manufacturer: CTS Electrocomponents; CurrentRating_mA: 25A; PositionCount: 6; SizeX_mm: 8.44; SizeY_mm: 8.79; SizeZ_mm: 2.65; SizeArea_mm2: 74.1876; SizeAreaWB_mm2: 112.6476

## Sheet PROC073C_Can_Interface.SchDoc: CAN Interface
size 431 x 279 mm; Date: Not shown in title block; ApprovedBy: Not shown in title block; CheckedBy: Not shown in title block; Author: Not shown in title block; CompanyName: Not shown in title block; DrawnBy: Charles F. Oladimeji; Engineer: Not shown in title block; Organization: Not shown in title block; Address1: Not shown in title block; Address2: Not shown in title block; Address3: Not shown in title block; Address4: Not shown in title block; DocumentNumber: 12; Revision: Use project parameter SCH_Rev; SheetNumber: 12; SheetTotal: 13; PageSetup: Record=PageOptions¦CenterHorizontal=True¦CenterVertical=True¦PrintScale=1.00¦XCorrection=1.00¦YCorrection=1.00¦PrintKind=0¦BorderSize=5000000¦LeftOffset=0¦BottomOffset=0¦Orientation=2¦PaperLength=1000¦PaperWidth=1000¦Scale=100¦PaperSource=15¦PrintQuality=600¦MediaType=1¦DitherType=10¦PaperKind=Letter¦PrintScaleMode=1

### Parts
C37  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C38  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C39  ValueDisplayed: 4700pF  [0402L]  (hidden comment: GCM155R71H472KA37D)
C40  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C41  ValueDisplayed: 0.1µF  [0402L]  (hidden comment: C0402C104K8RACTU)
C42  ValueDisplayed: 4700pF  [0402L]  (hidden comment: GCM155R71H472KA37D)
C43  ValueDisplayed: 0.1µF  [0402]  (hidden comment: C0402C104K8RACTU)
J3  M50-3930342  [FP-M50-3930342_HDR3-MFG]  (value not drawn)
J4  M50-3930342  [FP-M50-3930342_HDR3-MFG]  (value not drawn)
R3  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R68  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R69  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R70  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R71  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R78  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R79  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R80  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R81  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R82  ValueDisplayed: 0  [0201_Silk]  (hidden comment: CRCW02010000Z0ED)
R83  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R84  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R85  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R86  ValueDisplayed: 61.9  [0402L]  (hidden comment: CRCW040261R9FKED)
R87  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
R88  ValueDisplayed: 10.0k  [0402L]  (hidden comment: CRCW040210K0FKED)
R89  ValueDisplayed: 4.7k  [0402]  (hidden comment: CRCW04024K70JNED)
R216  ValueDisplayed: 0  [0402]  (hidden comment: ERJ-2GE0R00X)
U5  TCAN1042HGVDQ1  [D0008A_L]
U12  TCAN1042HGVDQ1  [D0008A_L]
U13  TS3A5018RSVR  [RSV0016A]

### Ports
CAN1_RX, CAN1_TX, CAN2_RX, CAN2_TX, MUX_IN_1 (in), RADAR_CS1, RADAR_GPIO_0, RADAR_MISO1, RADAR_MOSI1, RADAR_SPICLK1, SPI_CLK1, SPI_CS1, SPI_MISO1, SPI_MOSI1

### Nets
5V_IN: R69.2 R82.2
GND: C37.1 C38.1 C39.1 C40.1 C41.1 C42.1 C43.2 J3.2 J4.2 R71.2 R84.2 R89.1 U5.2(GND) U12.2(GND) U13.6(GND)
VCC_3V3: C38.2 C41.2 C43.1 R70.1 R83.1 R88.2 U5.5(VIO) U12.5(VIO) U13.14(V+)
CAN1_RX: R80.1 U13.3(NC2) ; port CAN1_RX
CAN1_TX: R78.1 U13.16(NC1) ; port CAN1_TX
CAN2_RX: R87.1 U13.9(NC3) ; port CAN2_RX
CAN2_TX: R85.1 U13.12(NC4) ; port CAN2_TX
MUX_IN_1: R88.1 U13.15(IN) ; port MUX_IN_1
RADAR_CS1: U13.10(COM4) ; port RADAR_CS1
RADAR_GPIO_0: R3.2 R216.2 ; port RADAR_GPIO_0
RADAR_MISO1: U13.2(COM1) ; port RADAR_MISO1
RADAR_MOSI1: U13.5(COM2) ; port RADAR_MOSI1
RADAR_SPICLK1: U13.7(COM3) ; port RADAR_SPICLK1
SPI_CLK1: U13.8(NO3) ; port SPI_CLK1
SPI_CS1: U13.11(NO4) ; port SPI_CS1
SPI_MISO1: U13.1(NO1) ; port SPI_MISO1
SPI_MOSI1: U13.4(NO2) ; port SPI_MOSI1
NetC37_2: C37.2 R69.1 U5.3(VCC)
NetC39_2: C39.2 R68.1 R79.2
NetC40_2: C40.2 R82.1 U12.3(VCC)
NetC42_2: C42.2 R81.1 R86.2
NetJ3_1: J3.1 R79.1 U5.6(CANL)
NetJ3_3: J3.3 R68.2 U5.7(CANH)
NetJ4_1: J4.1 R86.1 U12.6(CANL)
NetJ4_3: J4.3 R81.2 U12.7(CANH)
NetR3_1: R3.1 R70.2 R71.1 U5.8(STB)
NetR78_2: R78.2 U5.1(TXD)
NetR80_2: R80.2 U5.4(RXD)
NetR83_2: R83.2 R84.1 R216.1 U12.8(STB)
NetR85_2: R85.2 U12.1(TXD)
NetR87_2: R87.2 U12.4(RXD)
NetR89_2: R89.2 U13.13(~{EN})

### Notes on the sheet
- CAN_FD TRANSCEIVER
- (near J3) CANH
- (near J3) GND
- (near J3) CANL
- (near J4) CANH
- (near J4) GND
- (near J4) CANL
- CAN/SPI SELECTION
- MUX IN CONFIG
- S1.1 OFF   : SPI-1
- S1.1 ON     : CAN1 & CAN2

### Library data of the parts
C37 C38 C40 C41 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Value2: 10V; CompType: Capacitor; Cap_F: 100nF; AEC Category: Q200
C39 C42 = CMP-0006361-2: CAP, CERM, 4700 pF, 50 V, +/- 10%, X7R, AEC-Q200 Grade 1, 0402; Manufacturer: MuRata; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; Value1: Unknown; U/M: EA; Value: 4700pF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Cap_Case: 0402; Value2: 50V; AEC Qualified: Y; Cap_F: 4.7nF; AEC Category: Q200
C43 = CMP-0078241-1: CAP, CERM, 0.1 µF, 10 V,+/- 10%, X7R, 0402; Manufacturer: Kemet; TaMin_C: -55°C; Polarized: N; SizeAreaWB_mm2: 3; U/M: EA; Value: 0.1uF; TaMax_C: 125°C; SizeZ_mm: 0.6; SizeX_mm: 1; SizeY_mm: 0.5; Value2: 10V; CompType: Capacitor; Cap_F: 100nF; AEC Category: Q200
J3 J4 = CMP-0087785-1: CONN HEADER R/A 3POS 1.27MM; Manufacturer: Harwin; Row_Count: 1; Current_A: 1A; ContactFinish: Gold,Nickel
R3 R78 R80 R85 R87 R216 = CMP-0026992-3: RES, 0, 5%, 0.1 W, AEC-Q200 Grade 0, 0402; Manufacturer: Panasonic; Power_W: 100mW; TempCo: 600 ppm/C; Value_Code: 0000; Value: 0; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.1W; CompType: Resistor; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; SizeAreaWB_mm2: 3; INSTALLATION: DNP
R68 R79 R81 R86 = CMP-0026491-2: RES, 61.9, 1%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 100 ppm/C; Value_Code: 61R9; Value: 61.9; EIA_Code: E96; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
R69 R82 = CMP-0027008-4: as R4 on sheet PROC073C_HD_Connector_60Pin
R70 R71 R83 R84 R88 = CMP-0025958-3: as R52 on sheet PROC073C_HD_Connector_60Pin
R89 = CMP-0026938-5: RES, 4.7 k, 5%, 0.063 W, AEC-Q200 Grade 0, 0402; Manufacturer: Vishay-Dale; Power_W: 63mW; TempCo: 200 ppm/C; Value_Code: 4k70; Value: 4.7k; EIA_Code: E24; SizeX_mm: 1; SizeY_mm: 0.5; SizeZ_mm: 0.6; Value2: 0.063W; AEC Qualified: Y; VDC_V: 50V; AEC Category: Q200; AEC Grade: 0
U5 U12 = CMP-0075992-1: Automotive Fault Protected CAN Transceiver With Flexible Data-Rate, D0008A (SOIC-8); Manufacturer: Texas Instruments; Alternate PartNumber: TCAN1042HGVDRQ1; SizeAreaWB_mm2: 56.58; SizeArea_mm2: 30.38; SizeZ_mm: 1.75; SizeY_mm: 6.2; U/M: EA; CompType: IC; SizeX_mm: 4.9
U13 = CMP-0067415-1: 10-Ohm Quad SPDT Analog Switch, RSV0016A (UQFN-16); Alternate Manufacturer: Texas Instruments; SizeAreaWB_mm2: 10.08; U/M: EA; SizeZ_mm: 0.55; SizeX_mm: 1.8; SizeY_mm: 2.6; SizeArea_mm2: 4.68; CompType: IC